* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/siddhant/Documents/FreePDK45/ncsu_basekit/models/hspice/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/siddhant/Documents/FreePDK45/ncsu_basekit/models/hspice/tran_models/models_nom/NMOS_VTG.inc"
.include "SRAM_32x128_1rw.sp"

* Global Power Supplies
Vvdd vdd 0 1.1

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
XSRAM_32x128_1rw din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 vdd gnd SRAM_32x128_1rw

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f

* Important signals for debug
* bl:	xsram_32x128_1rw.xbank0.bl_0_0
* br:	xsram_32x128_1rw.xbank0.br_0_0
* s_en:	xsram_32x128_1rw.s_en
* q:	xSRAM_32x128_1rw.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xSRAM_32x128_1rw.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 01110011100001001110001110001100  to  address 1111100 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 00011111110111101101001100001000  to  address 0000001 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 10010010011100100000001100011111  to  address 1111110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 10010010011100100000001100011111 from address 1111110 (from port 0) during cycle 4 (20ns - 25ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 10010010011100100000001100011111 from address 1111110 (from port 0) during cycle 7 (35ns - 40ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 8 (40ns - 45ns)
*	Reading 10010010011100100000001100011111 from address 1111110 (from port 0) during cycle 9 (45ns - 50ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 11 (55ns - 60ns)
*	Writing 00010101011011111011100011101001  to  address 1111100 (from port 0) during cycle 12 (60ns - 65ns)
*	Writing 10101111100111000001110101010101  to  address 1111100 (from port 0) during cycle 16 (80ns - 85ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 10010010011100100000001100011111 from address 1111110 (from port 0) during cycle 18 (90ns - 95ns)
*	Writing 10011110110000110001101011100010  to  address 1111110 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 10011110110000110001101011100010 from address 1111110 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 10101111100111000001110101010101 from address 1111100 (from port 0) during cycle 24 (120ns - 125ns)
*	Writing 11011010111001101110001001010101  to  address 1111011 (from port 0) during cycle 25 (125ns - 130ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing 11011101110011000011100101110111  to  address 1111011 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 11011101110011000011100101110111 from address 1111011 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 11011101110011000011100101110111 from address 1111011 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 10101111100111000001110101010101 from address 1111100 (from port 0) during cycle 32 (160ns - 165ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 11011101110011000011100101110111 from address 1111011 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 10011110110000110001101011100010 from address 1111110 (from port 0) during cycle 35 (175ns - 180ns)
*	Reading 10101111100111000001110101010101 from address 1111100 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing 01111001111100111011110000110101  to  address 0000011 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 11011101110011000011100101110111 from address 1111011 (from port 0) during cycle 40 (200ns - 205ns)
*	Writing 00101000111011100000101010100011  to  address 0000011 (from port 0) during cycle 43 (215ns - 220ns)
*	Reading 00101000111011100000101010100011 from address 0000011 (from port 0) during cycle 45 (225ns - 230ns)
*	Writing 00001011110001001011000001100001  to  address 1111101 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 00101000111011100000101010100011 from address 0000011 (from port 0) during cycle 48 (240ns - 245ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 11011101110011000011100101110111 from address 1111011 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing 10101111000110111001010110011101  to  address 0000011 (from port 0) during cycle 53 (265ns - 270ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 00011111110111101101001100001000 from address 0000001 (from port 0) during cycle 55 (275ns - 280ns)
*	Reading 10101111000110111001010110011101 from address 0000011 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 10011110110000110001101011100010 from address 1111110 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 58 (290ns - 295ns)
*	Reading 10101111000110111001010110011101 from address 0000011 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 11111110001011001110000101011110  to  address 0000000 (from port 0) during cycle 61 (305ns - 310ns)
*	Writing 00100001100011101100100000110010  to  address 1111100 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 00100001100011101100100000110010 from address 1111100 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 10101101100011110100101010011010  to  address 0000000 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 10011110110000110001101011100010 from address 1111110 (from port 0) during cycle 66 (330ns - 335ns)
*	Reading 00100001100011101100100000110010 from address 1111100 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 10101101100011110100101010011010 from address 0000000 (from port 0) during cycle 69 (345ns - 350ns)
*	Writing 01001101100101001100000111110101  to  address 0000000 (from port 0) during cycle 70 (350ns - 355ns)
*	Reading 10101111000110111001010110011101 from address 0000011 (from port 0) during cycle 71 (355ns - 360ns)
*	Reading 11011101110011000011100101110111 from address 1111011 (from port 0) during cycle 72 (360ns - 365ns)
*	Writing 11011110001011011000100110011101  to  address 1111100 (from port 0) during cycle 73 (365ns - 370ns)
*	Writing 01000000010100100101100011001101  to  address 1111011 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing 10101101000001000111111100110111  to  address 0000001 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 01001101100101001100000111110101 from address 0000000 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 01001101100101001100000111110101 from address 0000000 (from port 0) during cycle 78 (390ns - 395ns)
*	Reading 01000000010100100101100011001101 from address 1111011 (from port 0) during cycle 79 (395ns - 400ns)
*	Writing 01100111111011101010001111011111  to  address 0000011 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 11000000011110001111111010011010  to  address 0000011 (from port 0) during cycle 82 (410ns - 415ns)
*	Reading 10101101000001000111111100110111 from address 0000001 (from port 0) during cycle 83 (415ns - 420ns)
*	Writing 00010010000001010101010101000100  to  address 0000000 (from port 0) during cycle 84 (420ns - 425ns)
*	Reading 10101101000001000111111100110111 from address 0000001 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 11011110001011011000100110011101 from address 1111100 (from port 0) during cycle 87 (435ns - 440ns)
*	Reading 10011110110000110001101011100010 from address 1111110 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 11000001000111001010111110110010  to  address 0000011 (from port 0) during cycle 91 (455ns - 460ns)
*	Reading 11000001000111001010111110110010 from address 0000011 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing 11011110011010010011010110101111  to  address 0000011 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 01000000010100100101100011001101 from address 1111011 (from port 0) during cycle 96 (480ns - 485ns)
*	Reading 10011110110000110001101011100010 from address 1111110 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 98 (490ns - 495ns)
*	Reading 01000000010100100101100011001101 from address 1111011 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 11011110001011011000100110011101 from address 1111100 (from port 0) during cycle 101 (505ns - 510ns)
*	Writing 00001110100011000001100011101111  to  address 1111110 (from port 0) during cycle 102 (510ns - 515ns)
*	Writing 11010001111000001100001111101010  to  address 1111011 (from port 0) during cycle 103 (515ns - 520ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 00010010000001010101010101000100 from address 0000000 (from port 0) during cycle 106 (530ns - 535ns)
*	Writing 00100100010000101010010110001110  to  address 0000011 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 10101101000001000111111100110111 from address 0000001 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 00010010000001010101010101000100 from address 0000000 (from port 0) during cycle 109 (545ns - 550ns)
*	Writing 00111010101100000111001101001101  to  address 1111110 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 00100100010000101010010110001110 from address 0000011 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 11010001111000001100001111101010 from address 1111011 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 00100100010000101010010110001110 from address 0000011 (from port 0) during cycle 113 (565ns - 570ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 11010001111000001100001111101010 from address 1111011 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 11010001111100100011010000110110  to  address 1111100 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 10101101000001000111111100110111 from address 0000001 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 00100100010000101010010110001110 from address 0000011 (from port 0) during cycle 122 (610ns - 615ns)
*	Reading 00100100010000101010010110001110 from address 0000011 (from port 0) during cycle 123 (615ns - 620ns)
*	Reading 11010001111100100011010000110110 from address 1111100 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 00111010101100000111001101001101 from address 1111110 (from port 0) during cycle 125 (625ns - 630ns)
*	Reading 11010001111000001100001111101010 from address 1111011 (from port 0) during cycle 126 (630ns - 635ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing 00110010110110100010110100111100  to  address 0000000 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing 00001101011111110100101011000001  to  address 0000011 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 00110010110110100010110100111100 from address 0000000 (from port 0) during cycle 133 (665ns - 670ns)
*	Writing 10111011100101111101001010100001  to  address 0000001 (from port 0) during cycle 134 (670ns - 675ns)
*	Writing 01101000001000000110110011000111  to  address 0000000 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 00111010101100000111001101001101 from address 1111110 (from port 0) during cycle 137 (685ns - 690ns)
*	Writing 10101101000000101010001100110111  to  address 1111100 (from port 0) during cycle 138 (690ns - 695ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 139 (695ns - 700ns)
*	Reading 11010001111000001100001111101010 from address 1111011 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 00001011110001001011000001100001 from address 1111101 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 10111000100001111011010111101100  to  address 1111011 (from port 0) during cycle 142 (710ns - 715ns)
*	Writing 10010100001001110010101010011010  to  address 0000001 (from port 0) during cycle 143 (715ns - 720ns)
*	Reading 10111000100001111011010111101100 from address 1111011 (from port 0) during cycle 148 (740ns - 745ns)
*	Reading 00001101011111110100101011000001 from address 0000011 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 00010000000011111000010111000001  to  address 1111110 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 10010100001001110010101010011010 from address 0000001 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 10010100001001110010101010011010 from address 0000001 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 01110001100010110001001001010010  to  address 1111110 (from port 0) during cycle 155 (775ns - 780ns)
*	Writing 10111001010100000001001101111010  to  address 0000011 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 01101000001000000110110011000111 from address 0000000 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 01110001100010110001001001010010 from address 1111110 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 10010100001001110010101010011010 from address 0000001 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 10111000100001111011010111101100 from address 1111011 (from port 0) during cycle 163 (815ns - 820ns)
*	Reading 10111000100001111011010111101100 from address 1111011 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 10101101000000101010001100110111 from address 1111100 (from port 0) during cycle 165 (825ns - 830ns)
*	Reading 10101101000000101010001100110111 from address 1111100 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 10101101000000101010001100110111 from address 1111100 (from port 0) during cycle 167 (835ns - 840ns)
*	Reading 10101101000000101010001100110111 from address 1111100 (from port 0) during cycle 168 (840ns - 845ns)
*	Writing 00010111111110001100010001101001  to  address 0000001 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 01110001100010110001001001010010 from address 1111110 (from port 0) during cycle 170 (850ns - 855ns)
*	Reading 01101000001000000110110011000111 from address 0000000 (from port 0) during cycle 171 (855ns - 860ns)
*	Reading 01110001100010110001001001010010 from address 1111110 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing 01011111011101011001101100100100  to  address 0000001 (from port 0) during cycle 173 (865ns - 870ns)
*	Writing 11110011101001000110100100001100  to  address 1111110 (from port 0) during cycle 174 (870ns - 875ns)
*	Writing 00010110110100101110100000110100  to  address 1111011 (from port 0) during cycle 176 (880ns - 885ns)
*	Reading 00010110110100101110100000110100 from address 1111011 (from port 0) during cycle 177 (885ns - 890ns)
*	Reading 01101000001000000110110011000111 from address 0000000 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 01011111100101000001010100111000  to  address 0000000 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 00010110110100101110100000110100 from address 1111011 (from port 0) during cycle 181 (905ns - 910ns)
*	Reading 10111001010100000001001101111010 from address 0000011 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 01011111011101011001101100100100 from address 0000001 (from port 0) during cycle 183 (915ns - 920ns)
*	Reading 10101101000000101010001100110111 from address 1111100 (from port 0) during cycle 184 (920ns - 925ns)
*	Writing 10001000100011101010100101110010  to  address 1111011 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 10111001010100000001001101111010 from address 0000011 (from port 0) during cycle 187 (935ns - 940ns)
*	Reading 10101101000000101010001100110111 from address 1111100 (from port 0) during cycle 188 (940ns - 945ns)
*	Reading 01011111100101000001010100111000 from address 0000000 (from port 0) during cycle 193 (965ns - 970ns)
*	Writing 10111100110011000011111101110001  to  address 0000001 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 01011111100101000001010100111000 from address 0000000 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 01011111100101000001010100111000 from address 0000000 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Reading 01011111100101000001010100111000 from address 0000000 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 10001000100011101010100101110010 from address 1111011 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 0), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 1), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 1), (520, 1), (525, 1), (530, 1), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 0), (40, 1), (45, 0), (50, 0), (55, 1), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 0), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 1), (375, 1), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 1), (810, 1), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 0), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 0.0v 39.745n 0.0v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 0), (125, 1), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 1), (360, 1), (365, 0), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 0), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 1), (555, 1), (560, 1), (565, 1), (570, 0), (575, 0), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 1), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 0), (695, 0), (700, 1), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 0), (920, 0), (925, 1), (930, 1), (935, 1), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 0), (500, 0), (505, 1), (510, 1), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 1), (40, 0), (45, 1), (50, 1), (55, 0), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 0), (135, 1), (140, 0), (145, 1), (150, 1), (155, 0), (160, 1), (165, 0), (170, 1), (175, 1), (180, 1), (185, 1), (190, 0), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 0), (270, 1), (275, 0), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 1), (555, 0), (560, 1), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 1), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 1), (935, 0), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 0.0v 159.745n 0.0v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 0), (90, 0), (95, 1), (100, 0), (105, 0), (110, 1), (115, 1), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 1), (210, 1), (215, 0), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 0), (260, 1), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 1), (390, 0), (395, 0), (400, 1), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 1), (465, 0), (470, 0), (475, 1), (480, 0), (485, 0), (490, 0), (495, 0), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 1), (580, 0), (585, 0), (590, 1), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 0), (670, 0), (675, 0), (680, 1), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 1), (950, 1), (955, 1), (960, 1), (965, 0), (970, 1), (975, 1), (980, 0), (985, 1), (990, 0), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 1.1v 4.745n 1.1v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 1.1v 239.745n 1.1v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 1.1v 389.745n 1.1v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 1.1v 504.745n 1.1v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 1.1v 579.745n 1.1v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 1.1v 664.745n 1.1v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 1.1v 684.745n 1.1v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 1.1v 814.745n 1.1v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 0.0v 994.745n 0.0v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 1.1v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 0), (65, 1), (70, 1), (75, 1), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 0), (220, 1), (225, 1), (230, 0), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 1), (335, 1), (340, 1), (345, 1), (350, 0), (355, 1), (360, 1), (365, 0), (370, 0), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 0), (460, 1), (465, 1), (470, 0), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 0), (540, 1), (545, 1), (550, 0), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 0), (675, 0), (680, 1), (685, 1), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 0), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 0), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 1.1v 4.745n 1.1v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 0.0v 234.745n 0.0v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 0.0v 354.745n 0.0v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 0.0v 554.745n 0.0v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 1.1 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.1 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 1.1 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 1.1 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 1.1 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 1.1 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 1.1 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 1.1 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 1.1 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 1.1 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 1.1 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 1.1 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 1.1 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 1.1 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 1.1 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 30
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=30.025n

* CHECK dout0_1 Vdout0_1ck5 = 0 time = 30
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=30.025n

* CHECK dout0_2 Vdout0_2ck5 = 0 time = 30
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=30.025n

* CHECK dout0_3 Vdout0_3ck5 = 1.1 time = 30
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=30.025n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 30
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=30.025n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 30
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=30.025n

* CHECK dout0_6 Vdout0_6ck5 = 0 time = 30
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=30.025n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 30
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=30.025n

* CHECK dout0_8 Vdout0_8ck5 = 1.1 time = 30
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=30.025n

* CHECK dout0_9 Vdout0_9ck5 = 1.1 time = 30
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=30.025n

* CHECK dout0_10 Vdout0_10ck5 = 0 time = 30
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=30.025n

* CHECK dout0_11 Vdout0_11ck5 = 0 time = 30
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=30.025n

* CHECK dout0_12 Vdout0_12ck5 = 1.1 time = 30
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=30.025n

* CHECK dout0_13 Vdout0_13ck5 = 0 time = 30
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=30.025n

* CHECK dout0_14 Vdout0_14ck5 = 1.1 time = 30
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=30.025n

* CHECK dout0_15 Vdout0_15ck5 = 1.1 time = 30
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=30.025n

* CHECK dout0_16 Vdout0_16ck5 = 0 time = 30
.meas tran vdout0_16ck5 FIND v(dout0_16) AT=30.025n

* CHECK dout0_17 Vdout0_17ck5 = 1.1 time = 30
.meas tran vdout0_17ck5 FIND v(dout0_17) AT=30.025n

* CHECK dout0_18 Vdout0_18ck5 = 1.1 time = 30
.meas tran vdout0_18ck5 FIND v(dout0_18) AT=30.025n

* CHECK dout0_19 Vdout0_19ck5 = 1.1 time = 30
.meas tran vdout0_19ck5 FIND v(dout0_19) AT=30.025n

* CHECK dout0_20 Vdout0_20ck5 = 1.1 time = 30
.meas tran vdout0_20ck5 FIND v(dout0_20) AT=30.025n

* CHECK dout0_21 Vdout0_21ck5 = 0 time = 30
.meas tran vdout0_21ck5 FIND v(dout0_21) AT=30.025n

* CHECK dout0_22 Vdout0_22ck5 = 1.1 time = 30
.meas tran vdout0_22ck5 FIND v(dout0_22) AT=30.025n

* CHECK dout0_23 Vdout0_23ck5 = 1.1 time = 30
.meas tran vdout0_23ck5 FIND v(dout0_23) AT=30.025n

* CHECK dout0_24 Vdout0_24ck5 = 1.1 time = 30
.meas tran vdout0_24ck5 FIND v(dout0_24) AT=30.025n

* CHECK dout0_25 Vdout0_25ck5 = 1.1 time = 30
.meas tran vdout0_25ck5 FIND v(dout0_25) AT=30.025n

* CHECK dout0_26 Vdout0_26ck5 = 1.1 time = 30
.meas tran vdout0_26ck5 FIND v(dout0_26) AT=30.025n

* CHECK dout0_27 Vdout0_27ck5 = 1.1 time = 30
.meas tran vdout0_27ck5 FIND v(dout0_27) AT=30.025n

* CHECK dout0_28 Vdout0_28ck5 = 1.1 time = 30
.meas tran vdout0_28ck5 FIND v(dout0_28) AT=30.025n

* CHECK dout0_29 Vdout0_29ck5 = 0 time = 30
.meas tran vdout0_29ck5 FIND v(dout0_29) AT=30.025n

* CHECK dout0_30 Vdout0_30ck5 = 0 time = 30
.meas tran vdout0_30ck5 FIND v(dout0_30) AT=30.025n

* CHECK dout0_31 Vdout0_31ck5 = 0 time = 30
.meas tran vdout0_31ck5 FIND v(dout0_31) AT=30.025n

* CHECK dout0_0 Vdout0_0ck7 = 1.1 time = 40
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=40.025n

* CHECK dout0_1 Vdout0_1ck7 = 1.1 time = 40
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=40.025n

* CHECK dout0_2 Vdout0_2ck7 = 1.1 time = 40
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=40.025n

* CHECK dout0_3 Vdout0_3ck7 = 1.1 time = 40
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=40.025n

* CHECK dout0_4 Vdout0_4ck7 = 1.1 time = 40
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=40.025n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 40
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=40.025n

* CHECK dout0_6 Vdout0_6ck7 = 0 time = 40
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=40.025n

* CHECK dout0_7 Vdout0_7ck7 = 0 time = 40
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=40.025n

* CHECK dout0_8 Vdout0_8ck7 = 1.1 time = 40
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=40.025n

* CHECK dout0_9 Vdout0_9ck7 = 1.1 time = 40
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=40.025n

* CHECK dout0_10 Vdout0_10ck7 = 0 time = 40
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=40.025n

* CHECK dout0_11 Vdout0_11ck7 = 0 time = 40
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=40.025n

* CHECK dout0_12 Vdout0_12ck7 = 0 time = 40
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=40.025n

* CHECK dout0_13 Vdout0_13ck7 = 0 time = 40
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=40.025n

* CHECK dout0_14 Vdout0_14ck7 = 0 time = 40
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=40.025n

* CHECK dout0_15 Vdout0_15ck7 = 0 time = 40
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=40.025n

* CHECK dout0_16 Vdout0_16ck7 = 0 time = 40
.meas tran vdout0_16ck7 FIND v(dout0_16) AT=40.025n

* CHECK dout0_17 Vdout0_17ck7 = 1.1 time = 40
.meas tran vdout0_17ck7 FIND v(dout0_17) AT=40.025n

* CHECK dout0_18 Vdout0_18ck7 = 0 time = 40
.meas tran vdout0_18ck7 FIND v(dout0_18) AT=40.025n

* CHECK dout0_19 Vdout0_19ck7 = 0 time = 40
.meas tran vdout0_19ck7 FIND v(dout0_19) AT=40.025n

* CHECK dout0_20 Vdout0_20ck7 = 1.1 time = 40
.meas tran vdout0_20ck7 FIND v(dout0_20) AT=40.025n

* CHECK dout0_21 Vdout0_21ck7 = 1.1 time = 40
.meas tran vdout0_21ck7 FIND v(dout0_21) AT=40.025n

* CHECK dout0_22 Vdout0_22ck7 = 1.1 time = 40
.meas tran vdout0_22ck7 FIND v(dout0_22) AT=40.025n

* CHECK dout0_23 Vdout0_23ck7 = 0 time = 40
.meas tran vdout0_23ck7 FIND v(dout0_23) AT=40.025n

* CHECK dout0_24 Vdout0_24ck7 = 0 time = 40
.meas tran vdout0_24ck7 FIND v(dout0_24) AT=40.025n

* CHECK dout0_25 Vdout0_25ck7 = 1.1 time = 40
.meas tran vdout0_25ck7 FIND v(dout0_25) AT=40.025n

* CHECK dout0_26 Vdout0_26ck7 = 0 time = 40
.meas tran vdout0_26ck7 FIND v(dout0_26) AT=40.025n

* CHECK dout0_27 Vdout0_27ck7 = 0 time = 40
.meas tran vdout0_27ck7 FIND v(dout0_27) AT=40.025n

* CHECK dout0_28 Vdout0_28ck7 = 1.1 time = 40
.meas tran vdout0_28ck7 FIND v(dout0_28) AT=40.025n

* CHECK dout0_29 Vdout0_29ck7 = 0 time = 40
.meas tran vdout0_29ck7 FIND v(dout0_29) AT=40.025n

* CHECK dout0_30 Vdout0_30ck7 = 0 time = 40
.meas tran vdout0_30ck7 FIND v(dout0_30) AT=40.025n

* CHECK dout0_31 Vdout0_31ck7 = 1.1 time = 40
.meas tran vdout0_31ck7 FIND v(dout0_31) AT=40.025n

* CHECK dout0_0 Vdout0_0ck8 = 0 time = 45
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=45.025n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 45
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=45.025n

* CHECK dout0_2 Vdout0_2ck8 = 0 time = 45
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=45.025n

* CHECK dout0_3 Vdout0_3ck8 = 1.1 time = 45
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=45.025n

* CHECK dout0_4 Vdout0_4ck8 = 0 time = 45
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=45.025n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 45
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=45.025n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 45
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=45.025n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 45
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=45.025n

* CHECK dout0_8 Vdout0_8ck8 = 1.1 time = 45
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=45.025n

* CHECK dout0_9 Vdout0_9ck8 = 1.1 time = 45
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=45.025n

* CHECK dout0_10 Vdout0_10ck8 = 0 time = 45
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=45.025n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 45
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=45.025n

* CHECK dout0_12 Vdout0_12ck8 = 1.1 time = 45
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=45.025n

* CHECK dout0_13 Vdout0_13ck8 = 0 time = 45
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=45.025n

* CHECK dout0_14 Vdout0_14ck8 = 1.1 time = 45
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=45.025n

* CHECK dout0_15 Vdout0_15ck8 = 1.1 time = 45
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=45.025n

* CHECK dout0_16 Vdout0_16ck8 = 0 time = 45
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=45.025n

* CHECK dout0_17 Vdout0_17ck8 = 1.1 time = 45
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=45.025n

* CHECK dout0_18 Vdout0_18ck8 = 1.1 time = 45
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=45.025n

* CHECK dout0_19 Vdout0_19ck8 = 1.1 time = 45
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=45.025n

* CHECK dout0_20 Vdout0_20ck8 = 1.1 time = 45
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=45.025n

* CHECK dout0_21 Vdout0_21ck8 = 0 time = 45
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=45.025n

* CHECK dout0_22 Vdout0_22ck8 = 1.1 time = 45
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=45.025n

* CHECK dout0_23 Vdout0_23ck8 = 1.1 time = 45
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=45.025n

* CHECK dout0_24 Vdout0_24ck8 = 1.1 time = 45
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=45.025n

* CHECK dout0_25 Vdout0_25ck8 = 1.1 time = 45
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=45.025n

* CHECK dout0_26 Vdout0_26ck8 = 1.1 time = 45
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=45.025n

* CHECK dout0_27 Vdout0_27ck8 = 1.1 time = 45
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=45.025n

* CHECK dout0_28 Vdout0_28ck8 = 1.1 time = 45
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=45.025n

* CHECK dout0_29 Vdout0_29ck8 = 0 time = 45
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=45.025n

* CHECK dout0_30 Vdout0_30ck8 = 0 time = 45
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=45.025n

* CHECK dout0_31 Vdout0_31ck8 = 0 time = 45
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=45.025n

* CHECK dout0_0 Vdout0_0ck9 = 1.1 time = 50
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=50.025n

* CHECK dout0_1 Vdout0_1ck9 = 1.1 time = 50
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=50.025n

* CHECK dout0_2 Vdout0_2ck9 = 1.1 time = 50
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=50.025n

* CHECK dout0_3 Vdout0_3ck9 = 1.1 time = 50
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=50.025n

* CHECK dout0_4 Vdout0_4ck9 = 1.1 time = 50
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=50.025n

* CHECK dout0_5 Vdout0_5ck9 = 0 time = 50
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=50.025n

* CHECK dout0_6 Vdout0_6ck9 = 0 time = 50
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=50.025n

* CHECK dout0_7 Vdout0_7ck9 = 0 time = 50
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=50.025n

* CHECK dout0_8 Vdout0_8ck9 = 1.1 time = 50
.meas tran vdout0_8ck9 FIND v(dout0_8) AT=50.025n

* CHECK dout0_9 Vdout0_9ck9 = 1.1 time = 50
.meas tran vdout0_9ck9 FIND v(dout0_9) AT=50.025n

* CHECK dout0_10 Vdout0_10ck9 = 0 time = 50
.meas tran vdout0_10ck9 FIND v(dout0_10) AT=50.025n

* CHECK dout0_11 Vdout0_11ck9 = 0 time = 50
.meas tran vdout0_11ck9 FIND v(dout0_11) AT=50.025n

* CHECK dout0_12 Vdout0_12ck9 = 0 time = 50
.meas tran vdout0_12ck9 FIND v(dout0_12) AT=50.025n

* CHECK dout0_13 Vdout0_13ck9 = 0 time = 50
.meas tran vdout0_13ck9 FIND v(dout0_13) AT=50.025n

* CHECK dout0_14 Vdout0_14ck9 = 0 time = 50
.meas tran vdout0_14ck9 FIND v(dout0_14) AT=50.025n

* CHECK dout0_15 Vdout0_15ck9 = 0 time = 50
.meas tran vdout0_15ck9 FIND v(dout0_15) AT=50.025n

* CHECK dout0_16 Vdout0_16ck9 = 0 time = 50
.meas tran vdout0_16ck9 FIND v(dout0_16) AT=50.025n

* CHECK dout0_17 Vdout0_17ck9 = 1.1 time = 50
.meas tran vdout0_17ck9 FIND v(dout0_17) AT=50.025n

* CHECK dout0_18 Vdout0_18ck9 = 0 time = 50
.meas tran vdout0_18ck9 FIND v(dout0_18) AT=50.025n

* CHECK dout0_19 Vdout0_19ck9 = 0 time = 50
.meas tran vdout0_19ck9 FIND v(dout0_19) AT=50.025n

* CHECK dout0_20 Vdout0_20ck9 = 1.1 time = 50
.meas tran vdout0_20ck9 FIND v(dout0_20) AT=50.025n

* CHECK dout0_21 Vdout0_21ck9 = 1.1 time = 50
.meas tran vdout0_21ck9 FIND v(dout0_21) AT=50.025n

* CHECK dout0_22 Vdout0_22ck9 = 1.1 time = 50
.meas tran vdout0_22ck9 FIND v(dout0_22) AT=50.025n

* CHECK dout0_23 Vdout0_23ck9 = 0 time = 50
.meas tran vdout0_23ck9 FIND v(dout0_23) AT=50.025n

* CHECK dout0_24 Vdout0_24ck9 = 0 time = 50
.meas tran vdout0_24ck9 FIND v(dout0_24) AT=50.025n

* CHECK dout0_25 Vdout0_25ck9 = 1.1 time = 50
.meas tran vdout0_25ck9 FIND v(dout0_25) AT=50.025n

* CHECK dout0_26 Vdout0_26ck9 = 0 time = 50
.meas tran vdout0_26ck9 FIND v(dout0_26) AT=50.025n

* CHECK dout0_27 Vdout0_27ck9 = 0 time = 50
.meas tran vdout0_27ck9 FIND v(dout0_27) AT=50.025n

* CHECK dout0_28 Vdout0_28ck9 = 1.1 time = 50
.meas tran vdout0_28ck9 FIND v(dout0_28) AT=50.025n

* CHECK dout0_29 Vdout0_29ck9 = 0 time = 50
.meas tran vdout0_29ck9 FIND v(dout0_29) AT=50.025n

* CHECK dout0_30 Vdout0_30ck9 = 0 time = 50
.meas tran vdout0_30ck9 FIND v(dout0_30) AT=50.025n

* CHECK dout0_31 Vdout0_31ck9 = 1.1 time = 50
.meas tran vdout0_31ck9 FIND v(dout0_31) AT=50.025n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 60
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=60.025n

* CHECK dout0_1 Vdout0_1ck11 = 0 time = 60
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=60.025n

* CHECK dout0_2 Vdout0_2ck11 = 0 time = 60
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=60.025n

* CHECK dout0_3 Vdout0_3ck11 = 1.1 time = 60
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=60.025n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 60
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=60.025n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 60
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=60.025n

* CHECK dout0_6 Vdout0_6ck11 = 0 time = 60
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=60.025n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 60
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=60.025n

* CHECK dout0_8 Vdout0_8ck11 = 1.1 time = 60
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=60.025n

* CHECK dout0_9 Vdout0_9ck11 = 1.1 time = 60
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=60.025n

* CHECK dout0_10 Vdout0_10ck11 = 0 time = 60
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=60.025n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 60
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=60.025n

* CHECK dout0_12 Vdout0_12ck11 = 1.1 time = 60
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=60.025n

* CHECK dout0_13 Vdout0_13ck11 = 0 time = 60
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=60.025n

* CHECK dout0_14 Vdout0_14ck11 = 1.1 time = 60
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=60.025n

* CHECK dout0_15 Vdout0_15ck11 = 1.1 time = 60
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=60.025n

* CHECK dout0_16 Vdout0_16ck11 = 0 time = 60
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=60.025n

* CHECK dout0_17 Vdout0_17ck11 = 1.1 time = 60
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=60.025n

* CHECK dout0_18 Vdout0_18ck11 = 1.1 time = 60
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=60.025n

* CHECK dout0_19 Vdout0_19ck11 = 1.1 time = 60
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=60.025n

* CHECK dout0_20 Vdout0_20ck11 = 1.1 time = 60
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=60.025n

* CHECK dout0_21 Vdout0_21ck11 = 0 time = 60
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=60.025n

* CHECK dout0_22 Vdout0_22ck11 = 1.1 time = 60
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=60.025n

* CHECK dout0_23 Vdout0_23ck11 = 1.1 time = 60
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=60.025n

* CHECK dout0_24 Vdout0_24ck11 = 1.1 time = 60
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=60.025n

* CHECK dout0_25 Vdout0_25ck11 = 1.1 time = 60
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=60.025n

* CHECK dout0_26 Vdout0_26ck11 = 1.1 time = 60
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=60.025n

* CHECK dout0_27 Vdout0_27ck11 = 1.1 time = 60
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=60.025n

* CHECK dout0_28 Vdout0_28ck11 = 1.1 time = 60
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=60.025n

* CHECK dout0_29 Vdout0_29ck11 = 0 time = 60
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=60.025n

* CHECK dout0_30 Vdout0_30ck11 = 0 time = 60
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=60.025n

* CHECK dout0_31 Vdout0_31ck11 = 0 time = 60
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=60.025n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 90
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=90.025n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 90
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=90.025n

* CHECK dout0_2 Vdout0_2ck17 = 0 time = 90
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=90.025n

* CHECK dout0_3 Vdout0_3ck17 = 1.1 time = 90
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=90.025n

* CHECK dout0_4 Vdout0_4ck17 = 0 time = 90
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=90.025n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 90
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=90.025n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 90
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=90.025n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 90
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=90.025n

* CHECK dout0_8 Vdout0_8ck17 = 1.1 time = 90
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=90.025n

* CHECK dout0_9 Vdout0_9ck17 = 1.1 time = 90
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=90.025n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 90
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=90.025n

* CHECK dout0_11 Vdout0_11ck17 = 0 time = 90
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=90.025n

* CHECK dout0_12 Vdout0_12ck17 = 1.1 time = 90
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=90.025n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 90
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=90.025n

* CHECK dout0_14 Vdout0_14ck17 = 1.1 time = 90
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=90.025n

* CHECK dout0_15 Vdout0_15ck17 = 1.1 time = 90
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=90.025n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 90
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=90.025n

* CHECK dout0_17 Vdout0_17ck17 = 1.1 time = 90
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=90.025n

* CHECK dout0_18 Vdout0_18ck17 = 1.1 time = 90
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=90.025n

* CHECK dout0_19 Vdout0_19ck17 = 1.1 time = 90
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=90.025n

* CHECK dout0_20 Vdout0_20ck17 = 1.1 time = 90
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=90.025n

* CHECK dout0_21 Vdout0_21ck17 = 0 time = 90
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=90.025n

* CHECK dout0_22 Vdout0_22ck17 = 1.1 time = 90
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=90.025n

* CHECK dout0_23 Vdout0_23ck17 = 1.1 time = 90
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=90.025n

* CHECK dout0_24 Vdout0_24ck17 = 1.1 time = 90
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=90.025n

* CHECK dout0_25 Vdout0_25ck17 = 1.1 time = 90
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=90.025n

* CHECK dout0_26 Vdout0_26ck17 = 1.1 time = 90
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=90.025n

* CHECK dout0_27 Vdout0_27ck17 = 1.1 time = 90
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=90.025n

* CHECK dout0_28 Vdout0_28ck17 = 1.1 time = 90
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=90.025n

* CHECK dout0_29 Vdout0_29ck17 = 0 time = 90
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=90.025n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 90
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=90.025n

* CHECK dout0_31 Vdout0_31ck17 = 0 time = 90
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=90.025n

* CHECK dout0_0 Vdout0_0ck18 = 1.1 time = 95
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=95.025n

* CHECK dout0_1 Vdout0_1ck18 = 1.1 time = 95
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=95.025n

* CHECK dout0_2 Vdout0_2ck18 = 1.1 time = 95
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=95.025n

* CHECK dout0_3 Vdout0_3ck18 = 1.1 time = 95
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=95.025n

* CHECK dout0_4 Vdout0_4ck18 = 1.1 time = 95
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=95.025n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 95
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=95.025n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 95
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=95.025n

* CHECK dout0_7 Vdout0_7ck18 = 0 time = 95
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=95.025n

* CHECK dout0_8 Vdout0_8ck18 = 1.1 time = 95
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=95.025n

* CHECK dout0_9 Vdout0_9ck18 = 1.1 time = 95
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=95.025n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 95
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=95.025n

* CHECK dout0_11 Vdout0_11ck18 = 0 time = 95
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=95.025n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 95
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=95.025n

* CHECK dout0_13 Vdout0_13ck18 = 0 time = 95
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=95.025n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 95
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=95.025n

* CHECK dout0_15 Vdout0_15ck18 = 0 time = 95
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=95.025n

* CHECK dout0_16 Vdout0_16ck18 = 0 time = 95
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=95.025n

* CHECK dout0_17 Vdout0_17ck18 = 1.1 time = 95
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=95.025n

* CHECK dout0_18 Vdout0_18ck18 = 0 time = 95
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=95.025n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 95
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=95.025n

* CHECK dout0_20 Vdout0_20ck18 = 1.1 time = 95
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=95.025n

* CHECK dout0_21 Vdout0_21ck18 = 1.1 time = 95
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=95.025n

* CHECK dout0_22 Vdout0_22ck18 = 1.1 time = 95
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=95.025n

* CHECK dout0_23 Vdout0_23ck18 = 0 time = 95
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=95.025n

* CHECK dout0_24 Vdout0_24ck18 = 0 time = 95
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=95.025n

* CHECK dout0_25 Vdout0_25ck18 = 1.1 time = 95
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=95.025n

* CHECK dout0_26 Vdout0_26ck18 = 0 time = 95
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=95.025n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 95
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=95.025n

* CHECK dout0_28 Vdout0_28ck18 = 1.1 time = 95
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=95.025n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 95
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=95.025n

* CHECK dout0_30 Vdout0_30ck18 = 0 time = 95
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=95.025n

* CHECK dout0_31 Vdout0_31ck18 = 1.1 time = 95
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=95.025n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 110
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=110.025n

* CHECK dout0_1 Vdout0_1ck21 = 1.1 time = 110
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=110.025n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 110
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=110.025n

* CHECK dout0_3 Vdout0_3ck21 = 0 time = 110
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=110.025n

* CHECK dout0_4 Vdout0_4ck21 = 0 time = 110
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=110.025n

* CHECK dout0_5 Vdout0_5ck21 = 1.1 time = 110
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=110.025n

* CHECK dout0_6 Vdout0_6ck21 = 1.1 time = 110
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=110.025n

* CHECK dout0_7 Vdout0_7ck21 = 1.1 time = 110
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=110.025n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 110
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=110.025n

* CHECK dout0_9 Vdout0_9ck21 = 1.1 time = 110
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=110.025n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 110
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=110.025n

* CHECK dout0_11 Vdout0_11ck21 = 1.1 time = 110
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=110.025n

* CHECK dout0_12 Vdout0_12ck21 = 1.1 time = 110
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=110.025n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 110
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=110.025n

* CHECK dout0_14 Vdout0_14ck21 = 0 time = 110
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=110.025n

* CHECK dout0_15 Vdout0_15ck21 = 0 time = 110
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=110.025n

* CHECK dout0_16 Vdout0_16ck21 = 1.1 time = 110
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=110.025n

* CHECK dout0_17 Vdout0_17ck21 = 1.1 time = 110
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=110.025n

* CHECK dout0_18 Vdout0_18ck21 = 0 time = 110
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=110.025n

* CHECK dout0_19 Vdout0_19ck21 = 0 time = 110
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=110.025n

* CHECK dout0_20 Vdout0_20ck21 = 0 time = 110
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=110.025n

* CHECK dout0_21 Vdout0_21ck21 = 0 time = 110
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=110.025n

* CHECK dout0_22 Vdout0_22ck21 = 1.1 time = 110
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=110.025n

* CHECK dout0_23 Vdout0_23ck21 = 1.1 time = 110
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=110.025n

* CHECK dout0_24 Vdout0_24ck21 = 0 time = 110
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=110.025n

* CHECK dout0_25 Vdout0_25ck21 = 1.1 time = 110
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=110.025n

* CHECK dout0_26 Vdout0_26ck21 = 1.1 time = 110
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=110.025n

* CHECK dout0_27 Vdout0_27ck21 = 1.1 time = 110
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=110.025n

* CHECK dout0_28 Vdout0_28ck21 = 1.1 time = 110
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=110.025n

* CHECK dout0_29 Vdout0_29ck21 = 0 time = 110
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=110.025n

* CHECK dout0_30 Vdout0_30ck21 = 0 time = 110
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=110.025n

* CHECK dout0_31 Vdout0_31ck21 = 1.1 time = 110
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=110.025n

* CHECK dout0_0 Vdout0_0ck24 = 1.1 time = 125
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=125.025n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 125
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=125.025n

* CHECK dout0_2 Vdout0_2ck24 = 1.1 time = 125
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=125.025n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 125
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=125.025n

* CHECK dout0_4 Vdout0_4ck24 = 1.1 time = 125
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=125.025n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 125
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=125.025n

* CHECK dout0_6 Vdout0_6ck24 = 1.1 time = 125
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=125.025n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 125
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=125.025n

* CHECK dout0_8 Vdout0_8ck24 = 1.1 time = 125
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=125.025n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 125
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=125.025n

* CHECK dout0_10 Vdout0_10ck24 = 1.1 time = 125
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=125.025n

* CHECK dout0_11 Vdout0_11ck24 = 1.1 time = 125
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=125.025n

* CHECK dout0_12 Vdout0_12ck24 = 1.1 time = 125
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=125.025n

* CHECK dout0_13 Vdout0_13ck24 = 0 time = 125
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=125.025n

* CHECK dout0_14 Vdout0_14ck24 = 0 time = 125
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=125.025n

* CHECK dout0_15 Vdout0_15ck24 = 0 time = 125
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=125.025n

* CHECK dout0_16 Vdout0_16ck24 = 0 time = 125
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=125.025n

* CHECK dout0_17 Vdout0_17ck24 = 0 time = 125
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=125.025n

* CHECK dout0_18 Vdout0_18ck24 = 1.1 time = 125
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=125.025n

* CHECK dout0_19 Vdout0_19ck24 = 1.1 time = 125
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=125.025n

* CHECK dout0_20 Vdout0_20ck24 = 1.1 time = 125
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=125.025n

* CHECK dout0_21 Vdout0_21ck24 = 0 time = 125
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=125.025n

* CHECK dout0_22 Vdout0_22ck24 = 0 time = 125
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=125.025n

* CHECK dout0_23 Vdout0_23ck24 = 1.1 time = 125
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=125.025n

* CHECK dout0_24 Vdout0_24ck24 = 1.1 time = 125
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=125.025n

* CHECK dout0_25 Vdout0_25ck24 = 1.1 time = 125
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=125.025n

* CHECK dout0_26 Vdout0_26ck24 = 1.1 time = 125
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=125.025n

* CHECK dout0_27 Vdout0_27ck24 = 1.1 time = 125
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=125.025n

* CHECK dout0_28 Vdout0_28ck24 = 0 time = 125
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=125.025n

* CHECK dout0_29 Vdout0_29ck24 = 1.1 time = 125
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=125.025n

* CHECK dout0_30 Vdout0_30ck24 = 0 time = 125
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=125.025n

* CHECK dout0_31 Vdout0_31ck24 = 1.1 time = 125
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=125.025n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 135
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=135.025n

* CHECK dout0_1 Vdout0_1ck26 = 0 time = 135
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=135.025n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 135
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=135.025n

* CHECK dout0_3 Vdout0_3ck26 = 1.1 time = 135
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=135.025n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 135
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=135.025n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 135
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=135.025n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 135
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=135.025n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 135
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=135.025n

* CHECK dout0_8 Vdout0_8ck26 = 1.1 time = 135
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=135.025n

* CHECK dout0_9 Vdout0_9ck26 = 1.1 time = 135
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=135.025n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 135
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=135.025n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 135
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=135.025n

* CHECK dout0_12 Vdout0_12ck26 = 1.1 time = 135
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=135.025n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 135
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=135.025n

* CHECK dout0_14 Vdout0_14ck26 = 1.1 time = 135
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=135.025n

* CHECK dout0_15 Vdout0_15ck26 = 1.1 time = 135
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=135.025n

* CHECK dout0_16 Vdout0_16ck26 = 0 time = 135
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=135.025n

* CHECK dout0_17 Vdout0_17ck26 = 1.1 time = 135
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=135.025n

* CHECK dout0_18 Vdout0_18ck26 = 1.1 time = 135
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=135.025n

* CHECK dout0_19 Vdout0_19ck26 = 1.1 time = 135
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=135.025n

* CHECK dout0_20 Vdout0_20ck26 = 1.1 time = 135
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=135.025n

* CHECK dout0_21 Vdout0_21ck26 = 0 time = 135
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=135.025n

* CHECK dout0_22 Vdout0_22ck26 = 1.1 time = 135
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=135.025n

* CHECK dout0_23 Vdout0_23ck26 = 1.1 time = 135
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=135.025n

* CHECK dout0_24 Vdout0_24ck26 = 1.1 time = 135
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=135.025n

* CHECK dout0_25 Vdout0_25ck26 = 1.1 time = 135
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=135.025n

* CHECK dout0_26 Vdout0_26ck26 = 1.1 time = 135
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=135.025n

* CHECK dout0_27 Vdout0_27ck26 = 1.1 time = 135
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=135.025n

* CHECK dout0_28 Vdout0_28ck26 = 1.1 time = 135
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=135.025n

* CHECK dout0_29 Vdout0_29ck26 = 0 time = 135
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=135.025n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 135
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=135.025n

* CHECK dout0_31 Vdout0_31ck26 = 0 time = 135
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=135.025n

* CHECK dout0_0 Vdout0_0ck28 = 0 time = 145
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=145.025n

* CHECK dout0_1 Vdout0_1ck28 = 0 time = 145
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=145.025n

* CHECK dout0_2 Vdout0_2ck28 = 0 time = 145
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=145.025n

* CHECK dout0_3 Vdout0_3ck28 = 1.1 time = 145
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=145.025n

* CHECK dout0_4 Vdout0_4ck28 = 0 time = 145
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=145.025n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 145
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=145.025n

* CHECK dout0_6 Vdout0_6ck28 = 0 time = 145
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=145.025n

* CHECK dout0_7 Vdout0_7ck28 = 0 time = 145
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=145.025n

* CHECK dout0_8 Vdout0_8ck28 = 1.1 time = 145
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=145.025n

* CHECK dout0_9 Vdout0_9ck28 = 1.1 time = 145
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=145.025n

* CHECK dout0_10 Vdout0_10ck28 = 0 time = 145
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=145.025n

* CHECK dout0_11 Vdout0_11ck28 = 0 time = 145
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=145.025n

* CHECK dout0_12 Vdout0_12ck28 = 1.1 time = 145
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=145.025n

* CHECK dout0_13 Vdout0_13ck28 = 0 time = 145
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=145.025n

* CHECK dout0_14 Vdout0_14ck28 = 1.1 time = 145
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=145.025n

* CHECK dout0_15 Vdout0_15ck28 = 1.1 time = 145
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=145.025n

* CHECK dout0_16 Vdout0_16ck28 = 0 time = 145
.meas tran vdout0_16ck28 FIND v(dout0_16) AT=145.025n

* CHECK dout0_17 Vdout0_17ck28 = 1.1 time = 145
.meas tran vdout0_17ck28 FIND v(dout0_17) AT=145.025n

* CHECK dout0_18 Vdout0_18ck28 = 1.1 time = 145
.meas tran vdout0_18ck28 FIND v(dout0_18) AT=145.025n

* CHECK dout0_19 Vdout0_19ck28 = 1.1 time = 145
.meas tran vdout0_19ck28 FIND v(dout0_19) AT=145.025n

* CHECK dout0_20 Vdout0_20ck28 = 1.1 time = 145
.meas tran vdout0_20ck28 FIND v(dout0_20) AT=145.025n

* CHECK dout0_21 Vdout0_21ck28 = 0 time = 145
.meas tran vdout0_21ck28 FIND v(dout0_21) AT=145.025n

* CHECK dout0_22 Vdout0_22ck28 = 1.1 time = 145
.meas tran vdout0_22ck28 FIND v(dout0_22) AT=145.025n

* CHECK dout0_23 Vdout0_23ck28 = 1.1 time = 145
.meas tran vdout0_23ck28 FIND v(dout0_23) AT=145.025n

* CHECK dout0_24 Vdout0_24ck28 = 1.1 time = 145
.meas tran vdout0_24ck28 FIND v(dout0_24) AT=145.025n

* CHECK dout0_25 Vdout0_25ck28 = 1.1 time = 145
.meas tran vdout0_25ck28 FIND v(dout0_25) AT=145.025n

* CHECK dout0_26 Vdout0_26ck28 = 1.1 time = 145
.meas tran vdout0_26ck28 FIND v(dout0_26) AT=145.025n

* CHECK dout0_27 Vdout0_27ck28 = 1.1 time = 145
.meas tran vdout0_27ck28 FIND v(dout0_27) AT=145.025n

* CHECK dout0_28 Vdout0_28ck28 = 1.1 time = 145
.meas tran vdout0_28ck28 FIND v(dout0_28) AT=145.025n

* CHECK dout0_29 Vdout0_29ck28 = 0 time = 145
.meas tran vdout0_29ck28 FIND v(dout0_29) AT=145.025n

* CHECK dout0_30 Vdout0_30ck28 = 0 time = 145
.meas tran vdout0_30ck28 FIND v(dout0_30) AT=145.025n

* CHECK dout0_31 Vdout0_31ck28 = 0 time = 145
.meas tran vdout0_31ck28 FIND v(dout0_31) AT=145.025n

* CHECK dout0_0 Vdout0_0ck29 = 1.1 time = 150
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=150.025n

* CHECK dout0_1 Vdout0_1ck29 = 1.1 time = 150
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=150.025n

* CHECK dout0_2 Vdout0_2ck29 = 1.1 time = 150
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=150.025n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 150
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=150.025n

* CHECK dout0_4 Vdout0_4ck29 = 1.1 time = 150
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=150.025n

* CHECK dout0_5 Vdout0_5ck29 = 1.1 time = 150
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=150.025n

* CHECK dout0_6 Vdout0_6ck29 = 1.1 time = 150
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=150.025n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 150
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=150.025n

* CHECK dout0_8 Vdout0_8ck29 = 1.1 time = 150
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=150.025n

* CHECK dout0_9 Vdout0_9ck29 = 0 time = 150
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=150.025n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 150
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=150.025n

* CHECK dout0_11 Vdout0_11ck29 = 1.1 time = 150
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=150.025n

* CHECK dout0_12 Vdout0_12ck29 = 1.1 time = 150
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=150.025n

* CHECK dout0_13 Vdout0_13ck29 = 1.1 time = 150
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=150.025n

* CHECK dout0_14 Vdout0_14ck29 = 0 time = 150
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=150.025n

* CHECK dout0_15 Vdout0_15ck29 = 0 time = 150
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=150.025n

* CHECK dout0_16 Vdout0_16ck29 = 0 time = 150
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=150.025n

* CHECK dout0_17 Vdout0_17ck29 = 0 time = 150
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=150.025n

* CHECK dout0_18 Vdout0_18ck29 = 1.1 time = 150
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=150.025n

* CHECK dout0_19 Vdout0_19ck29 = 1.1 time = 150
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=150.025n

* CHECK dout0_20 Vdout0_20ck29 = 0 time = 150
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=150.025n

* CHECK dout0_21 Vdout0_21ck29 = 0 time = 150
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=150.025n

* CHECK dout0_22 Vdout0_22ck29 = 1.1 time = 150
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=150.025n

* CHECK dout0_23 Vdout0_23ck29 = 1.1 time = 150
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=150.025n

* CHECK dout0_24 Vdout0_24ck29 = 1.1 time = 150
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=150.025n

* CHECK dout0_25 Vdout0_25ck29 = 0 time = 150
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=150.025n

* CHECK dout0_26 Vdout0_26ck29 = 1.1 time = 150
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=150.025n

* CHECK dout0_27 Vdout0_27ck29 = 1.1 time = 150
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=150.025n

* CHECK dout0_28 Vdout0_28ck29 = 1.1 time = 150
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=150.025n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 150
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=150.025n

* CHECK dout0_30 Vdout0_30ck29 = 1.1 time = 150
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=150.025n

* CHECK dout0_31 Vdout0_31ck29 = 1.1 time = 150
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=150.025n

* CHECK dout0_0 Vdout0_0ck30 = 1.1 time = 155
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=155.025n

* CHECK dout0_1 Vdout0_1ck30 = 1.1 time = 155
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=155.025n

* CHECK dout0_2 Vdout0_2ck30 = 1.1 time = 155
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=155.025n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 155
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=155.025n

* CHECK dout0_4 Vdout0_4ck30 = 1.1 time = 155
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=155.025n

* CHECK dout0_5 Vdout0_5ck30 = 1.1 time = 155
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=155.025n

* CHECK dout0_6 Vdout0_6ck30 = 1.1 time = 155
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=155.025n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 155
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=155.025n

* CHECK dout0_8 Vdout0_8ck30 = 1.1 time = 155
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=155.025n

* CHECK dout0_9 Vdout0_9ck30 = 0 time = 155
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=155.025n

* CHECK dout0_10 Vdout0_10ck30 = 0 time = 155
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=155.025n

* CHECK dout0_11 Vdout0_11ck30 = 1.1 time = 155
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=155.025n

* CHECK dout0_12 Vdout0_12ck30 = 1.1 time = 155
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=155.025n

* CHECK dout0_13 Vdout0_13ck30 = 1.1 time = 155
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=155.025n

* CHECK dout0_14 Vdout0_14ck30 = 0 time = 155
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=155.025n

* CHECK dout0_15 Vdout0_15ck30 = 0 time = 155
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=155.025n

* CHECK dout0_16 Vdout0_16ck30 = 0 time = 155
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=155.025n

* CHECK dout0_17 Vdout0_17ck30 = 0 time = 155
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=155.025n

* CHECK dout0_18 Vdout0_18ck30 = 1.1 time = 155
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=155.025n

* CHECK dout0_19 Vdout0_19ck30 = 1.1 time = 155
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=155.025n

* CHECK dout0_20 Vdout0_20ck30 = 0 time = 155
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=155.025n

* CHECK dout0_21 Vdout0_21ck30 = 0 time = 155
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=155.025n

* CHECK dout0_22 Vdout0_22ck30 = 1.1 time = 155
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=155.025n

* CHECK dout0_23 Vdout0_23ck30 = 1.1 time = 155
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=155.025n

* CHECK dout0_24 Vdout0_24ck30 = 1.1 time = 155
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=155.025n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 155
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=155.025n

* CHECK dout0_26 Vdout0_26ck30 = 1.1 time = 155
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=155.025n

* CHECK dout0_27 Vdout0_27ck30 = 1.1 time = 155
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=155.025n

* CHECK dout0_28 Vdout0_28ck30 = 1.1 time = 155
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=155.025n

* CHECK dout0_29 Vdout0_29ck30 = 0 time = 155
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=155.025n

* CHECK dout0_30 Vdout0_30ck30 = 1.1 time = 155
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=155.025n

* CHECK dout0_31 Vdout0_31ck30 = 1.1 time = 155
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=155.025n

* CHECK dout0_0 Vdout0_0ck31 = 0 time = 160
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=160.025n

* CHECK dout0_1 Vdout0_1ck31 = 0 time = 160
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=160.025n

* CHECK dout0_2 Vdout0_2ck31 = 0 time = 160
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=160.025n

* CHECK dout0_3 Vdout0_3ck31 = 1.1 time = 160
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=160.025n

* CHECK dout0_4 Vdout0_4ck31 = 0 time = 160
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=160.025n

* CHECK dout0_5 Vdout0_5ck31 = 0 time = 160
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=160.025n

* CHECK dout0_6 Vdout0_6ck31 = 0 time = 160
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=160.025n

* CHECK dout0_7 Vdout0_7ck31 = 0 time = 160
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=160.025n

* CHECK dout0_8 Vdout0_8ck31 = 1.1 time = 160
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=160.025n

* CHECK dout0_9 Vdout0_9ck31 = 1.1 time = 160
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=160.025n

* CHECK dout0_10 Vdout0_10ck31 = 0 time = 160
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=160.025n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 160
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=160.025n

* CHECK dout0_12 Vdout0_12ck31 = 1.1 time = 160
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=160.025n

* CHECK dout0_13 Vdout0_13ck31 = 0 time = 160
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=160.025n

* CHECK dout0_14 Vdout0_14ck31 = 1.1 time = 160
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=160.025n

* CHECK dout0_15 Vdout0_15ck31 = 1.1 time = 160
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=160.025n

* CHECK dout0_16 Vdout0_16ck31 = 0 time = 160
.meas tran vdout0_16ck31 FIND v(dout0_16) AT=160.025n

* CHECK dout0_17 Vdout0_17ck31 = 1.1 time = 160
.meas tran vdout0_17ck31 FIND v(dout0_17) AT=160.025n

* CHECK dout0_18 Vdout0_18ck31 = 1.1 time = 160
.meas tran vdout0_18ck31 FIND v(dout0_18) AT=160.025n

* CHECK dout0_19 Vdout0_19ck31 = 1.1 time = 160
.meas tran vdout0_19ck31 FIND v(dout0_19) AT=160.025n

* CHECK dout0_20 Vdout0_20ck31 = 1.1 time = 160
.meas tran vdout0_20ck31 FIND v(dout0_20) AT=160.025n

* CHECK dout0_21 Vdout0_21ck31 = 0 time = 160
.meas tran vdout0_21ck31 FIND v(dout0_21) AT=160.025n

* CHECK dout0_22 Vdout0_22ck31 = 1.1 time = 160
.meas tran vdout0_22ck31 FIND v(dout0_22) AT=160.025n

* CHECK dout0_23 Vdout0_23ck31 = 1.1 time = 160
.meas tran vdout0_23ck31 FIND v(dout0_23) AT=160.025n

* CHECK dout0_24 Vdout0_24ck31 = 1.1 time = 160
.meas tran vdout0_24ck31 FIND v(dout0_24) AT=160.025n

* CHECK dout0_25 Vdout0_25ck31 = 1.1 time = 160
.meas tran vdout0_25ck31 FIND v(dout0_25) AT=160.025n

* CHECK dout0_26 Vdout0_26ck31 = 1.1 time = 160
.meas tran vdout0_26ck31 FIND v(dout0_26) AT=160.025n

* CHECK dout0_27 Vdout0_27ck31 = 1.1 time = 160
.meas tran vdout0_27ck31 FIND v(dout0_27) AT=160.025n

* CHECK dout0_28 Vdout0_28ck31 = 1.1 time = 160
.meas tran vdout0_28ck31 FIND v(dout0_28) AT=160.025n

* CHECK dout0_29 Vdout0_29ck31 = 0 time = 160
.meas tran vdout0_29ck31 FIND v(dout0_29) AT=160.025n

* CHECK dout0_30 Vdout0_30ck31 = 0 time = 160
.meas tran vdout0_30ck31 FIND v(dout0_30) AT=160.025n

* CHECK dout0_31 Vdout0_31ck31 = 0 time = 160
.meas tran vdout0_31ck31 FIND v(dout0_31) AT=160.025n

* CHECK dout0_0 Vdout0_0ck32 = 1.1 time = 165
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=165.025n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 165
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=165.025n

* CHECK dout0_2 Vdout0_2ck32 = 1.1 time = 165
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=165.025n

* CHECK dout0_3 Vdout0_3ck32 = 0 time = 165
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=165.025n

* CHECK dout0_4 Vdout0_4ck32 = 1.1 time = 165
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=165.025n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 165
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=165.025n

* CHECK dout0_6 Vdout0_6ck32 = 1.1 time = 165
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=165.025n

* CHECK dout0_7 Vdout0_7ck32 = 0 time = 165
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=165.025n

* CHECK dout0_8 Vdout0_8ck32 = 1.1 time = 165
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=165.025n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 165
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=165.025n

* CHECK dout0_10 Vdout0_10ck32 = 1.1 time = 165
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=165.025n

* CHECK dout0_11 Vdout0_11ck32 = 1.1 time = 165
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=165.025n

* CHECK dout0_12 Vdout0_12ck32 = 1.1 time = 165
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=165.025n

* CHECK dout0_13 Vdout0_13ck32 = 0 time = 165
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=165.025n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 165
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=165.025n

* CHECK dout0_15 Vdout0_15ck32 = 0 time = 165
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=165.025n

* CHECK dout0_16 Vdout0_16ck32 = 0 time = 165
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=165.025n

* CHECK dout0_17 Vdout0_17ck32 = 0 time = 165
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=165.025n

* CHECK dout0_18 Vdout0_18ck32 = 1.1 time = 165
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=165.025n

* CHECK dout0_19 Vdout0_19ck32 = 1.1 time = 165
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=165.025n

* CHECK dout0_20 Vdout0_20ck32 = 1.1 time = 165
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=165.025n

* CHECK dout0_21 Vdout0_21ck32 = 0 time = 165
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=165.025n

* CHECK dout0_22 Vdout0_22ck32 = 0 time = 165
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=165.025n

* CHECK dout0_23 Vdout0_23ck32 = 1.1 time = 165
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=165.025n

* CHECK dout0_24 Vdout0_24ck32 = 1.1 time = 165
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=165.025n

* CHECK dout0_25 Vdout0_25ck32 = 1.1 time = 165
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=165.025n

* CHECK dout0_26 Vdout0_26ck32 = 1.1 time = 165
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=165.025n

* CHECK dout0_27 Vdout0_27ck32 = 1.1 time = 165
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=165.025n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 165
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=165.025n

* CHECK dout0_29 Vdout0_29ck32 = 1.1 time = 165
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=165.025n

* CHECK dout0_30 Vdout0_30ck32 = 0 time = 165
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=165.025n

* CHECK dout0_31 Vdout0_31ck32 = 1.1 time = 165
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=165.025n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 170
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=170.025n

* CHECK dout0_1 Vdout0_1ck33 = 0 time = 170
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=170.025n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 170
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=170.025n

* CHECK dout0_3 Vdout0_3ck33 = 1.1 time = 170
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=170.025n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 170
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=170.025n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 170
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=170.025n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 170
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=170.025n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 170
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=170.025n

* CHECK dout0_8 Vdout0_8ck33 = 1.1 time = 170
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=170.025n

* CHECK dout0_9 Vdout0_9ck33 = 1.1 time = 170
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=170.025n

* CHECK dout0_10 Vdout0_10ck33 = 0 time = 170
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=170.025n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 170
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=170.025n

* CHECK dout0_12 Vdout0_12ck33 = 1.1 time = 170
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=170.025n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 170
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=170.025n

* CHECK dout0_14 Vdout0_14ck33 = 1.1 time = 170
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=170.025n

* CHECK dout0_15 Vdout0_15ck33 = 1.1 time = 170
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=170.025n

* CHECK dout0_16 Vdout0_16ck33 = 0 time = 170
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=170.025n

* CHECK dout0_17 Vdout0_17ck33 = 1.1 time = 170
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=170.025n

* CHECK dout0_18 Vdout0_18ck33 = 1.1 time = 170
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=170.025n

* CHECK dout0_19 Vdout0_19ck33 = 1.1 time = 170
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=170.025n

* CHECK dout0_20 Vdout0_20ck33 = 1.1 time = 170
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=170.025n

* CHECK dout0_21 Vdout0_21ck33 = 0 time = 170
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=170.025n

* CHECK dout0_22 Vdout0_22ck33 = 1.1 time = 170
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=170.025n

* CHECK dout0_23 Vdout0_23ck33 = 1.1 time = 170
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=170.025n

* CHECK dout0_24 Vdout0_24ck33 = 1.1 time = 170
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=170.025n

* CHECK dout0_25 Vdout0_25ck33 = 1.1 time = 170
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=170.025n

* CHECK dout0_26 Vdout0_26ck33 = 1.1 time = 170
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=170.025n

* CHECK dout0_27 Vdout0_27ck33 = 1.1 time = 170
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=170.025n

* CHECK dout0_28 Vdout0_28ck33 = 1.1 time = 170
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=170.025n

* CHECK dout0_29 Vdout0_29ck33 = 0 time = 170
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=170.025n

* CHECK dout0_30 Vdout0_30ck33 = 0 time = 170
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=170.025n

* CHECK dout0_31 Vdout0_31ck33 = 0 time = 170
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=170.025n

* CHECK dout0_0 Vdout0_0ck34 = 1.1 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 1.1 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 1.1 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 1.1 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 1.1 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 1.1 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 1.1 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 0 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 1.1 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 1.1 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 1.1 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 0 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 0 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 1.1 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 1.1 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 0 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 0 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 1.1 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 1.1 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 1.1 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 1.1 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 1.1 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 1.1 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 0 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 1.1 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 1.1 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 180
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=180.025n

* CHECK dout0_1 Vdout0_1ck35 = 1.1 time = 180
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=180.025n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 180
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=180.025n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 180
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=180.025n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 180
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=180.025n

* CHECK dout0_5 Vdout0_5ck35 = 1.1 time = 180
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=180.025n

* CHECK dout0_6 Vdout0_6ck35 = 1.1 time = 180
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=180.025n

* CHECK dout0_7 Vdout0_7ck35 = 1.1 time = 180
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=180.025n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 180
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=180.025n

* CHECK dout0_9 Vdout0_9ck35 = 1.1 time = 180
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=180.025n

* CHECK dout0_10 Vdout0_10ck35 = 0 time = 180
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=180.025n

* CHECK dout0_11 Vdout0_11ck35 = 1.1 time = 180
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=180.025n

* CHECK dout0_12 Vdout0_12ck35 = 1.1 time = 180
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=180.025n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 180
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=180.025n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 180
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=180.025n

* CHECK dout0_15 Vdout0_15ck35 = 0 time = 180
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=180.025n

* CHECK dout0_16 Vdout0_16ck35 = 1.1 time = 180
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=180.025n

* CHECK dout0_17 Vdout0_17ck35 = 1.1 time = 180
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=180.025n

* CHECK dout0_18 Vdout0_18ck35 = 0 time = 180
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=180.025n

* CHECK dout0_19 Vdout0_19ck35 = 0 time = 180
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=180.025n

* CHECK dout0_20 Vdout0_20ck35 = 0 time = 180
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=180.025n

* CHECK dout0_21 Vdout0_21ck35 = 0 time = 180
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=180.025n

* CHECK dout0_22 Vdout0_22ck35 = 1.1 time = 180
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=180.025n

* CHECK dout0_23 Vdout0_23ck35 = 1.1 time = 180
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=180.025n

* CHECK dout0_24 Vdout0_24ck35 = 0 time = 180
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=180.025n

* CHECK dout0_25 Vdout0_25ck35 = 1.1 time = 180
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=180.025n

* CHECK dout0_26 Vdout0_26ck35 = 1.1 time = 180
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=180.025n

* CHECK dout0_27 Vdout0_27ck35 = 1.1 time = 180
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=180.025n

* CHECK dout0_28 Vdout0_28ck35 = 1.1 time = 180
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=180.025n

* CHECK dout0_29 Vdout0_29ck35 = 0 time = 180
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=180.025n

* CHECK dout0_30 Vdout0_30ck35 = 0 time = 180
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=180.025n

* CHECK dout0_31 Vdout0_31ck35 = 1.1 time = 180
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=180.025n

* CHECK dout0_0 Vdout0_0ck36 = 1.1 time = 185
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=185.025n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 185
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=185.025n

* CHECK dout0_2 Vdout0_2ck36 = 1.1 time = 185
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=185.025n

* CHECK dout0_3 Vdout0_3ck36 = 0 time = 185
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=185.025n

* CHECK dout0_4 Vdout0_4ck36 = 1.1 time = 185
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=185.025n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 185
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=185.025n

* CHECK dout0_6 Vdout0_6ck36 = 1.1 time = 185
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=185.025n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 185
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=185.025n

* CHECK dout0_8 Vdout0_8ck36 = 1.1 time = 185
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=185.025n

* CHECK dout0_9 Vdout0_9ck36 = 0 time = 185
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=185.025n

* CHECK dout0_10 Vdout0_10ck36 = 1.1 time = 185
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=185.025n

* CHECK dout0_11 Vdout0_11ck36 = 1.1 time = 185
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=185.025n

* CHECK dout0_12 Vdout0_12ck36 = 1.1 time = 185
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=185.025n

* CHECK dout0_13 Vdout0_13ck36 = 0 time = 185
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=185.025n

* CHECK dout0_14 Vdout0_14ck36 = 0 time = 185
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=185.025n

* CHECK dout0_15 Vdout0_15ck36 = 0 time = 185
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=185.025n

* CHECK dout0_16 Vdout0_16ck36 = 0 time = 185
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=185.025n

* CHECK dout0_17 Vdout0_17ck36 = 0 time = 185
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=185.025n

* CHECK dout0_18 Vdout0_18ck36 = 1.1 time = 185
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=185.025n

* CHECK dout0_19 Vdout0_19ck36 = 1.1 time = 185
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=185.025n

* CHECK dout0_20 Vdout0_20ck36 = 1.1 time = 185
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=185.025n

* CHECK dout0_21 Vdout0_21ck36 = 0 time = 185
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=185.025n

* CHECK dout0_22 Vdout0_22ck36 = 0 time = 185
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=185.025n

* CHECK dout0_23 Vdout0_23ck36 = 1.1 time = 185
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=185.025n

* CHECK dout0_24 Vdout0_24ck36 = 1.1 time = 185
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=185.025n

* CHECK dout0_25 Vdout0_25ck36 = 1.1 time = 185
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=185.025n

* CHECK dout0_26 Vdout0_26ck36 = 1.1 time = 185
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=185.025n

* CHECK dout0_27 Vdout0_27ck36 = 1.1 time = 185
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=185.025n

* CHECK dout0_28 Vdout0_28ck36 = 0 time = 185
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=185.025n

* CHECK dout0_29 Vdout0_29ck36 = 1.1 time = 185
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=185.025n

* CHECK dout0_30 Vdout0_30ck36 = 0 time = 185
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=185.025n

* CHECK dout0_31 Vdout0_31ck36 = 1.1 time = 185
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=185.025n

* CHECK dout0_0 Vdout0_0ck38 = 0 time = 195
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=195.025n

* CHECK dout0_1 Vdout0_1ck38 = 0 time = 195
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=195.025n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 195
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=195.025n

* CHECK dout0_3 Vdout0_3ck38 = 1.1 time = 195
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=195.025n

* CHECK dout0_4 Vdout0_4ck38 = 0 time = 195
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=195.025n

* CHECK dout0_5 Vdout0_5ck38 = 0 time = 195
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=195.025n

* CHECK dout0_6 Vdout0_6ck38 = 0 time = 195
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=195.025n

* CHECK dout0_7 Vdout0_7ck38 = 0 time = 195
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=195.025n

* CHECK dout0_8 Vdout0_8ck38 = 1.1 time = 195
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=195.025n

* CHECK dout0_9 Vdout0_9ck38 = 1.1 time = 195
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=195.025n

* CHECK dout0_10 Vdout0_10ck38 = 0 time = 195
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=195.025n

* CHECK dout0_11 Vdout0_11ck38 = 0 time = 195
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=195.025n

* CHECK dout0_12 Vdout0_12ck38 = 1.1 time = 195
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=195.025n

* CHECK dout0_13 Vdout0_13ck38 = 0 time = 195
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=195.025n

* CHECK dout0_14 Vdout0_14ck38 = 1.1 time = 195
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=195.025n

* CHECK dout0_15 Vdout0_15ck38 = 1.1 time = 195
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=195.025n

* CHECK dout0_16 Vdout0_16ck38 = 0 time = 195
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=195.025n

* CHECK dout0_17 Vdout0_17ck38 = 1.1 time = 195
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=195.025n

* CHECK dout0_18 Vdout0_18ck38 = 1.1 time = 195
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=195.025n

* CHECK dout0_19 Vdout0_19ck38 = 1.1 time = 195
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=195.025n

* CHECK dout0_20 Vdout0_20ck38 = 1.1 time = 195
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=195.025n

* CHECK dout0_21 Vdout0_21ck38 = 0 time = 195
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=195.025n

* CHECK dout0_22 Vdout0_22ck38 = 1.1 time = 195
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=195.025n

* CHECK dout0_23 Vdout0_23ck38 = 1.1 time = 195
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=195.025n

* CHECK dout0_24 Vdout0_24ck38 = 1.1 time = 195
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=195.025n

* CHECK dout0_25 Vdout0_25ck38 = 1.1 time = 195
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=195.025n

* CHECK dout0_26 Vdout0_26ck38 = 1.1 time = 195
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=195.025n

* CHECK dout0_27 Vdout0_27ck38 = 1.1 time = 195
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=195.025n

* CHECK dout0_28 Vdout0_28ck38 = 1.1 time = 195
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=195.025n

* CHECK dout0_29 Vdout0_29ck38 = 0 time = 195
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=195.025n

* CHECK dout0_30 Vdout0_30ck38 = 0 time = 195
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=195.025n

* CHECK dout0_31 Vdout0_31ck38 = 0 time = 195
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=195.025n

* CHECK dout0_0 Vdout0_0ck40 = 1.1 time = 205
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=205.025n

* CHECK dout0_1 Vdout0_1ck40 = 1.1 time = 205
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=205.025n

* CHECK dout0_2 Vdout0_2ck40 = 1.1 time = 205
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=205.025n

* CHECK dout0_3 Vdout0_3ck40 = 0 time = 205
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=205.025n

* CHECK dout0_4 Vdout0_4ck40 = 1.1 time = 205
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=205.025n

* CHECK dout0_5 Vdout0_5ck40 = 1.1 time = 205
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=205.025n

* CHECK dout0_6 Vdout0_6ck40 = 1.1 time = 205
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=205.025n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 205
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=205.025n

* CHECK dout0_8 Vdout0_8ck40 = 1.1 time = 205
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=205.025n

* CHECK dout0_9 Vdout0_9ck40 = 0 time = 205
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=205.025n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 205
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=205.025n

* CHECK dout0_11 Vdout0_11ck40 = 1.1 time = 205
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=205.025n

* CHECK dout0_12 Vdout0_12ck40 = 1.1 time = 205
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=205.025n

* CHECK dout0_13 Vdout0_13ck40 = 1.1 time = 205
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=205.025n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 205
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=205.025n

* CHECK dout0_15 Vdout0_15ck40 = 0 time = 205
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=205.025n

* CHECK dout0_16 Vdout0_16ck40 = 0 time = 205
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=205.025n

* CHECK dout0_17 Vdout0_17ck40 = 0 time = 205
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=205.025n

* CHECK dout0_18 Vdout0_18ck40 = 1.1 time = 205
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=205.025n

* CHECK dout0_19 Vdout0_19ck40 = 1.1 time = 205
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=205.025n

* CHECK dout0_20 Vdout0_20ck40 = 0 time = 205
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=205.025n

* CHECK dout0_21 Vdout0_21ck40 = 0 time = 205
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=205.025n

* CHECK dout0_22 Vdout0_22ck40 = 1.1 time = 205
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=205.025n

* CHECK dout0_23 Vdout0_23ck40 = 1.1 time = 205
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=205.025n

* CHECK dout0_24 Vdout0_24ck40 = 1.1 time = 205
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=205.025n

* CHECK dout0_25 Vdout0_25ck40 = 0 time = 205
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=205.025n

* CHECK dout0_26 Vdout0_26ck40 = 1.1 time = 205
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=205.025n

* CHECK dout0_27 Vdout0_27ck40 = 1.1 time = 205
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=205.025n

* CHECK dout0_28 Vdout0_28ck40 = 1.1 time = 205
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=205.025n

* CHECK dout0_29 Vdout0_29ck40 = 0 time = 205
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=205.025n

* CHECK dout0_30 Vdout0_30ck40 = 1.1 time = 205
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=205.025n

* CHECK dout0_31 Vdout0_31ck40 = 1.1 time = 205
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=205.025n

* CHECK dout0_0 Vdout0_0ck45 = 1.1 time = 230
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=230.025n

* CHECK dout0_1 Vdout0_1ck45 = 1.1 time = 230
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=230.025n

* CHECK dout0_2 Vdout0_2ck45 = 0 time = 230
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=230.025n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 230
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=230.025n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 230
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=230.025n

* CHECK dout0_5 Vdout0_5ck45 = 1.1 time = 230
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=230.025n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 230
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=230.025n

* CHECK dout0_7 Vdout0_7ck45 = 1.1 time = 230
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=230.025n

* CHECK dout0_8 Vdout0_8ck45 = 0 time = 230
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=230.025n

* CHECK dout0_9 Vdout0_9ck45 = 1.1 time = 230
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=230.025n

* CHECK dout0_10 Vdout0_10ck45 = 0 time = 230
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=230.025n

* CHECK dout0_11 Vdout0_11ck45 = 1.1 time = 230
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=230.025n

* CHECK dout0_12 Vdout0_12ck45 = 0 time = 230
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=230.025n

* CHECK dout0_13 Vdout0_13ck45 = 0 time = 230
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=230.025n

* CHECK dout0_14 Vdout0_14ck45 = 0 time = 230
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=230.025n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 230
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=230.025n

* CHECK dout0_16 Vdout0_16ck45 = 0 time = 230
.meas tran vdout0_16ck45 FIND v(dout0_16) AT=230.025n

* CHECK dout0_17 Vdout0_17ck45 = 1.1 time = 230
.meas tran vdout0_17ck45 FIND v(dout0_17) AT=230.025n

* CHECK dout0_18 Vdout0_18ck45 = 1.1 time = 230
.meas tran vdout0_18ck45 FIND v(dout0_18) AT=230.025n

* CHECK dout0_19 Vdout0_19ck45 = 1.1 time = 230
.meas tran vdout0_19ck45 FIND v(dout0_19) AT=230.025n

* CHECK dout0_20 Vdout0_20ck45 = 0 time = 230
.meas tran vdout0_20ck45 FIND v(dout0_20) AT=230.025n

* CHECK dout0_21 Vdout0_21ck45 = 1.1 time = 230
.meas tran vdout0_21ck45 FIND v(dout0_21) AT=230.025n

* CHECK dout0_22 Vdout0_22ck45 = 1.1 time = 230
.meas tran vdout0_22ck45 FIND v(dout0_22) AT=230.025n

* CHECK dout0_23 Vdout0_23ck45 = 1.1 time = 230
.meas tran vdout0_23ck45 FIND v(dout0_23) AT=230.025n

* CHECK dout0_24 Vdout0_24ck45 = 0 time = 230
.meas tran vdout0_24ck45 FIND v(dout0_24) AT=230.025n

* CHECK dout0_25 Vdout0_25ck45 = 0 time = 230
.meas tran vdout0_25ck45 FIND v(dout0_25) AT=230.025n

* CHECK dout0_26 Vdout0_26ck45 = 0 time = 230
.meas tran vdout0_26ck45 FIND v(dout0_26) AT=230.025n

* CHECK dout0_27 Vdout0_27ck45 = 1.1 time = 230
.meas tran vdout0_27ck45 FIND v(dout0_27) AT=230.025n

* CHECK dout0_28 Vdout0_28ck45 = 0 time = 230
.meas tran vdout0_28ck45 FIND v(dout0_28) AT=230.025n

* CHECK dout0_29 Vdout0_29ck45 = 1.1 time = 230
.meas tran vdout0_29ck45 FIND v(dout0_29) AT=230.025n

* CHECK dout0_30 Vdout0_30ck45 = 0 time = 230
.meas tran vdout0_30ck45 FIND v(dout0_30) AT=230.025n

* CHECK dout0_31 Vdout0_31ck45 = 0 time = 230
.meas tran vdout0_31ck45 FIND v(dout0_31) AT=230.025n

* CHECK dout0_0 Vdout0_0ck48 = 1.1 time = 245
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=245.025n

* CHECK dout0_1 Vdout0_1ck48 = 1.1 time = 245
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=245.025n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 245
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=245.025n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 245
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=245.025n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 245
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=245.025n

* CHECK dout0_5 Vdout0_5ck48 = 1.1 time = 245
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=245.025n

* CHECK dout0_6 Vdout0_6ck48 = 0 time = 245
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=245.025n

* CHECK dout0_7 Vdout0_7ck48 = 1.1 time = 245
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=245.025n

* CHECK dout0_8 Vdout0_8ck48 = 0 time = 245
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=245.025n

* CHECK dout0_9 Vdout0_9ck48 = 1.1 time = 245
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=245.025n

* CHECK dout0_10 Vdout0_10ck48 = 0 time = 245
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=245.025n

* CHECK dout0_11 Vdout0_11ck48 = 1.1 time = 245
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=245.025n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 245
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=245.025n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 245
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=245.025n

* CHECK dout0_14 Vdout0_14ck48 = 0 time = 245
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=245.025n

* CHECK dout0_15 Vdout0_15ck48 = 0 time = 245
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=245.025n

* CHECK dout0_16 Vdout0_16ck48 = 0 time = 245
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=245.025n

* CHECK dout0_17 Vdout0_17ck48 = 1.1 time = 245
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=245.025n

* CHECK dout0_18 Vdout0_18ck48 = 1.1 time = 245
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=245.025n

* CHECK dout0_19 Vdout0_19ck48 = 1.1 time = 245
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=245.025n

* CHECK dout0_20 Vdout0_20ck48 = 0 time = 245
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=245.025n

* CHECK dout0_21 Vdout0_21ck48 = 1.1 time = 245
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=245.025n

* CHECK dout0_22 Vdout0_22ck48 = 1.1 time = 245
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=245.025n

* CHECK dout0_23 Vdout0_23ck48 = 1.1 time = 245
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=245.025n

* CHECK dout0_24 Vdout0_24ck48 = 0 time = 245
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=245.025n

* CHECK dout0_25 Vdout0_25ck48 = 0 time = 245
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=245.025n

* CHECK dout0_26 Vdout0_26ck48 = 0 time = 245
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=245.025n

* CHECK dout0_27 Vdout0_27ck48 = 1.1 time = 245
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=245.025n

* CHECK dout0_28 Vdout0_28ck48 = 0 time = 245
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=245.025n

* CHECK dout0_29 Vdout0_29ck48 = 1.1 time = 245
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=245.025n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 245
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=245.025n

* CHECK dout0_31 Vdout0_31ck48 = 0 time = 245
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=245.025n

* CHECK dout0_0 Vdout0_0ck49 = 0 time = 250
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=250.025n

* CHECK dout0_1 Vdout0_1ck49 = 0 time = 250
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=250.025n

* CHECK dout0_2 Vdout0_2ck49 = 0 time = 250
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=250.025n

* CHECK dout0_3 Vdout0_3ck49 = 1.1 time = 250
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=250.025n

* CHECK dout0_4 Vdout0_4ck49 = 0 time = 250
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=250.025n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 250
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=250.025n

* CHECK dout0_6 Vdout0_6ck49 = 0 time = 250
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=250.025n

* CHECK dout0_7 Vdout0_7ck49 = 0 time = 250
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=250.025n

* CHECK dout0_8 Vdout0_8ck49 = 1.1 time = 250
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=250.025n

* CHECK dout0_9 Vdout0_9ck49 = 1.1 time = 250
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=250.025n

* CHECK dout0_10 Vdout0_10ck49 = 0 time = 250
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=250.025n

* CHECK dout0_11 Vdout0_11ck49 = 0 time = 250
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=250.025n

* CHECK dout0_12 Vdout0_12ck49 = 1.1 time = 250
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=250.025n

* CHECK dout0_13 Vdout0_13ck49 = 0 time = 250
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=250.025n

* CHECK dout0_14 Vdout0_14ck49 = 1.1 time = 250
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=250.025n

* CHECK dout0_15 Vdout0_15ck49 = 1.1 time = 250
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=250.025n

* CHECK dout0_16 Vdout0_16ck49 = 0 time = 250
.meas tran vdout0_16ck49 FIND v(dout0_16) AT=250.025n

* CHECK dout0_17 Vdout0_17ck49 = 1.1 time = 250
.meas tran vdout0_17ck49 FIND v(dout0_17) AT=250.025n

* CHECK dout0_18 Vdout0_18ck49 = 1.1 time = 250
.meas tran vdout0_18ck49 FIND v(dout0_18) AT=250.025n

* CHECK dout0_19 Vdout0_19ck49 = 1.1 time = 250
.meas tran vdout0_19ck49 FIND v(dout0_19) AT=250.025n

* CHECK dout0_20 Vdout0_20ck49 = 1.1 time = 250
.meas tran vdout0_20ck49 FIND v(dout0_20) AT=250.025n

* CHECK dout0_21 Vdout0_21ck49 = 0 time = 250
.meas tran vdout0_21ck49 FIND v(dout0_21) AT=250.025n

* CHECK dout0_22 Vdout0_22ck49 = 1.1 time = 250
.meas tran vdout0_22ck49 FIND v(dout0_22) AT=250.025n

* CHECK dout0_23 Vdout0_23ck49 = 1.1 time = 250
.meas tran vdout0_23ck49 FIND v(dout0_23) AT=250.025n

* CHECK dout0_24 Vdout0_24ck49 = 1.1 time = 250
.meas tran vdout0_24ck49 FIND v(dout0_24) AT=250.025n

* CHECK dout0_25 Vdout0_25ck49 = 1.1 time = 250
.meas tran vdout0_25ck49 FIND v(dout0_25) AT=250.025n

* CHECK dout0_26 Vdout0_26ck49 = 1.1 time = 250
.meas tran vdout0_26ck49 FIND v(dout0_26) AT=250.025n

* CHECK dout0_27 Vdout0_27ck49 = 1.1 time = 250
.meas tran vdout0_27ck49 FIND v(dout0_27) AT=250.025n

* CHECK dout0_28 Vdout0_28ck49 = 1.1 time = 250
.meas tran vdout0_28ck49 FIND v(dout0_28) AT=250.025n

* CHECK dout0_29 Vdout0_29ck49 = 0 time = 250
.meas tran vdout0_29ck49 FIND v(dout0_29) AT=250.025n

* CHECK dout0_30 Vdout0_30ck49 = 0 time = 250
.meas tran vdout0_30ck49 FIND v(dout0_30) AT=250.025n

* CHECK dout0_31 Vdout0_31ck49 = 0 time = 250
.meas tran vdout0_31ck49 FIND v(dout0_31) AT=250.025n

* CHECK dout0_0 Vdout0_0ck51 = 1.1 time = 260
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=260.025n

* CHECK dout0_1 Vdout0_1ck51 = 1.1 time = 260
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=260.025n

* CHECK dout0_2 Vdout0_2ck51 = 1.1 time = 260
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=260.025n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 260
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=260.025n

* CHECK dout0_4 Vdout0_4ck51 = 1.1 time = 260
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=260.025n

* CHECK dout0_5 Vdout0_5ck51 = 1.1 time = 260
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=260.025n

* CHECK dout0_6 Vdout0_6ck51 = 1.1 time = 260
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=260.025n

* CHECK dout0_7 Vdout0_7ck51 = 0 time = 260
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=260.025n

* CHECK dout0_8 Vdout0_8ck51 = 1.1 time = 260
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=260.025n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 260
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=260.025n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 260
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=260.025n

* CHECK dout0_11 Vdout0_11ck51 = 1.1 time = 260
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=260.025n

* CHECK dout0_12 Vdout0_12ck51 = 1.1 time = 260
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=260.025n

* CHECK dout0_13 Vdout0_13ck51 = 1.1 time = 260
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=260.025n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 260
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=260.025n

* CHECK dout0_15 Vdout0_15ck51 = 0 time = 260
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=260.025n

* CHECK dout0_16 Vdout0_16ck51 = 0 time = 260
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=260.025n

* CHECK dout0_17 Vdout0_17ck51 = 0 time = 260
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=260.025n

* CHECK dout0_18 Vdout0_18ck51 = 1.1 time = 260
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=260.025n

* CHECK dout0_19 Vdout0_19ck51 = 1.1 time = 260
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=260.025n

* CHECK dout0_20 Vdout0_20ck51 = 0 time = 260
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=260.025n

* CHECK dout0_21 Vdout0_21ck51 = 0 time = 260
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=260.025n

* CHECK dout0_22 Vdout0_22ck51 = 1.1 time = 260
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=260.025n

* CHECK dout0_23 Vdout0_23ck51 = 1.1 time = 260
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=260.025n

* CHECK dout0_24 Vdout0_24ck51 = 1.1 time = 260
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=260.025n

* CHECK dout0_25 Vdout0_25ck51 = 0 time = 260
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=260.025n

* CHECK dout0_26 Vdout0_26ck51 = 1.1 time = 260
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=260.025n

* CHECK dout0_27 Vdout0_27ck51 = 1.1 time = 260
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=260.025n

* CHECK dout0_28 Vdout0_28ck51 = 1.1 time = 260
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=260.025n

* CHECK dout0_29 Vdout0_29ck51 = 0 time = 260
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=260.025n

* CHECK dout0_30 Vdout0_30ck51 = 1.1 time = 260
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=260.025n

* CHECK dout0_31 Vdout0_31ck51 = 1.1 time = 260
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=260.025n

* CHECK dout0_0 Vdout0_0ck54 = 1.1 time = 275
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=275.025n

* CHECK dout0_1 Vdout0_1ck54 = 0 time = 275
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=275.025n

* CHECK dout0_2 Vdout0_2ck54 = 0 time = 275
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=275.025n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 275
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=275.025n

* CHECK dout0_4 Vdout0_4ck54 = 0 time = 275
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=275.025n

* CHECK dout0_5 Vdout0_5ck54 = 1.1 time = 275
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=275.025n

* CHECK dout0_6 Vdout0_6ck54 = 1.1 time = 275
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=275.025n

* CHECK dout0_7 Vdout0_7ck54 = 0 time = 275
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=275.025n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 275
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=275.025n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 275
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=275.025n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 275
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=275.025n

* CHECK dout0_11 Vdout0_11ck54 = 0 time = 275
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=275.025n

* CHECK dout0_12 Vdout0_12ck54 = 1.1 time = 275
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=275.025n

* CHECK dout0_13 Vdout0_13ck54 = 1.1 time = 275
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=275.025n

* CHECK dout0_14 Vdout0_14ck54 = 0 time = 275
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=275.025n

* CHECK dout0_15 Vdout0_15ck54 = 1.1 time = 275
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=275.025n

* CHECK dout0_16 Vdout0_16ck54 = 0 time = 275
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=275.025n

* CHECK dout0_17 Vdout0_17ck54 = 0 time = 275
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=275.025n

* CHECK dout0_18 Vdout0_18ck54 = 1.1 time = 275
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=275.025n

* CHECK dout0_19 Vdout0_19ck54 = 0 time = 275
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=275.025n

* CHECK dout0_20 Vdout0_20ck54 = 0 time = 275
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=275.025n

* CHECK dout0_21 Vdout0_21ck54 = 0 time = 275
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=275.025n

* CHECK dout0_22 Vdout0_22ck54 = 1.1 time = 275
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=275.025n

* CHECK dout0_23 Vdout0_23ck54 = 1.1 time = 275
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=275.025n

* CHECK dout0_24 Vdout0_24ck54 = 1.1 time = 275
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=275.025n

* CHECK dout0_25 Vdout0_25ck54 = 1.1 time = 275
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=275.025n

* CHECK dout0_26 Vdout0_26ck54 = 0 time = 275
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=275.025n

* CHECK dout0_27 Vdout0_27ck54 = 1.1 time = 275
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=275.025n

* CHECK dout0_28 Vdout0_28ck54 = 0 time = 275
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=275.025n

* CHECK dout0_29 Vdout0_29ck54 = 0 time = 275
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=275.025n

* CHECK dout0_30 Vdout0_30ck54 = 0 time = 275
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=275.025n

* CHECK dout0_31 Vdout0_31ck54 = 0 time = 275
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=275.025n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 280
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=280.025n

* CHECK dout0_1 Vdout0_1ck55 = 0 time = 280
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=280.025n

* CHECK dout0_2 Vdout0_2ck55 = 0 time = 280
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=280.025n

* CHECK dout0_3 Vdout0_3ck55 = 1.1 time = 280
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=280.025n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 280
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=280.025n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 280
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=280.025n

* CHECK dout0_6 Vdout0_6ck55 = 0 time = 280
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=280.025n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 280
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=280.025n

* CHECK dout0_8 Vdout0_8ck55 = 1.1 time = 280
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=280.025n

* CHECK dout0_9 Vdout0_9ck55 = 1.1 time = 280
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=280.025n

* CHECK dout0_10 Vdout0_10ck55 = 0 time = 280
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=280.025n

* CHECK dout0_11 Vdout0_11ck55 = 0 time = 280
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=280.025n

* CHECK dout0_12 Vdout0_12ck55 = 1.1 time = 280
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=280.025n

* CHECK dout0_13 Vdout0_13ck55 = 0 time = 280
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=280.025n

* CHECK dout0_14 Vdout0_14ck55 = 1.1 time = 280
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=280.025n

* CHECK dout0_15 Vdout0_15ck55 = 1.1 time = 280
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=280.025n

* CHECK dout0_16 Vdout0_16ck55 = 0 time = 280
.meas tran vdout0_16ck55 FIND v(dout0_16) AT=280.025n

* CHECK dout0_17 Vdout0_17ck55 = 1.1 time = 280
.meas tran vdout0_17ck55 FIND v(dout0_17) AT=280.025n

* CHECK dout0_18 Vdout0_18ck55 = 1.1 time = 280
.meas tran vdout0_18ck55 FIND v(dout0_18) AT=280.025n

* CHECK dout0_19 Vdout0_19ck55 = 1.1 time = 280
.meas tran vdout0_19ck55 FIND v(dout0_19) AT=280.025n

* CHECK dout0_20 Vdout0_20ck55 = 1.1 time = 280
.meas tran vdout0_20ck55 FIND v(dout0_20) AT=280.025n

* CHECK dout0_21 Vdout0_21ck55 = 0 time = 280
.meas tran vdout0_21ck55 FIND v(dout0_21) AT=280.025n

* CHECK dout0_22 Vdout0_22ck55 = 1.1 time = 280
.meas tran vdout0_22ck55 FIND v(dout0_22) AT=280.025n

* CHECK dout0_23 Vdout0_23ck55 = 1.1 time = 280
.meas tran vdout0_23ck55 FIND v(dout0_23) AT=280.025n

* CHECK dout0_24 Vdout0_24ck55 = 1.1 time = 280
.meas tran vdout0_24ck55 FIND v(dout0_24) AT=280.025n

* CHECK dout0_25 Vdout0_25ck55 = 1.1 time = 280
.meas tran vdout0_25ck55 FIND v(dout0_25) AT=280.025n

* CHECK dout0_26 Vdout0_26ck55 = 1.1 time = 280
.meas tran vdout0_26ck55 FIND v(dout0_26) AT=280.025n

* CHECK dout0_27 Vdout0_27ck55 = 1.1 time = 280
.meas tran vdout0_27ck55 FIND v(dout0_27) AT=280.025n

* CHECK dout0_28 Vdout0_28ck55 = 1.1 time = 280
.meas tran vdout0_28ck55 FIND v(dout0_28) AT=280.025n

* CHECK dout0_29 Vdout0_29ck55 = 0 time = 280
.meas tran vdout0_29ck55 FIND v(dout0_29) AT=280.025n

* CHECK dout0_30 Vdout0_30ck55 = 0 time = 280
.meas tran vdout0_30ck55 FIND v(dout0_30) AT=280.025n

* CHECK dout0_31 Vdout0_31ck55 = 0 time = 280
.meas tran vdout0_31ck55 FIND v(dout0_31) AT=280.025n

* CHECK dout0_0 Vdout0_0ck56 = 1.1 time = 285
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=285.025n

* CHECK dout0_1 Vdout0_1ck56 = 0 time = 285
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=285.025n

* CHECK dout0_2 Vdout0_2ck56 = 1.1 time = 285
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=285.025n

* CHECK dout0_3 Vdout0_3ck56 = 1.1 time = 285
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=285.025n

* CHECK dout0_4 Vdout0_4ck56 = 1.1 time = 285
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=285.025n

* CHECK dout0_5 Vdout0_5ck56 = 0 time = 285
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=285.025n

* CHECK dout0_6 Vdout0_6ck56 = 0 time = 285
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=285.025n

* CHECK dout0_7 Vdout0_7ck56 = 1.1 time = 285
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=285.025n

* CHECK dout0_8 Vdout0_8ck56 = 1.1 time = 285
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=285.025n

* CHECK dout0_9 Vdout0_9ck56 = 0 time = 285
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=285.025n

* CHECK dout0_10 Vdout0_10ck56 = 1.1 time = 285
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=285.025n

* CHECK dout0_11 Vdout0_11ck56 = 0 time = 285
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=285.025n

* CHECK dout0_12 Vdout0_12ck56 = 1.1 time = 285
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=285.025n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 285
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=285.025n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 285
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=285.025n

* CHECK dout0_15 Vdout0_15ck56 = 1.1 time = 285
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=285.025n

* CHECK dout0_16 Vdout0_16ck56 = 1.1 time = 285
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=285.025n

* CHECK dout0_17 Vdout0_17ck56 = 1.1 time = 285
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=285.025n

* CHECK dout0_18 Vdout0_18ck56 = 0 time = 285
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=285.025n

* CHECK dout0_19 Vdout0_19ck56 = 1.1 time = 285
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=285.025n

* CHECK dout0_20 Vdout0_20ck56 = 1.1 time = 285
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=285.025n

* CHECK dout0_21 Vdout0_21ck56 = 0 time = 285
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=285.025n

* CHECK dout0_22 Vdout0_22ck56 = 0 time = 285
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=285.025n

* CHECK dout0_23 Vdout0_23ck56 = 0 time = 285
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=285.025n

* CHECK dout0_24 Vdout0_24ck56 = 1.1 time = 285
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=285.025n

* CHECK dout0_25 Vdout0_25ck56 = 1.1 time = 285
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=285.025n

* CHECK dout0_26 Vdout0_26ck56 = 1.1 time = 285
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=285.025n

* CHECK dout0_27 Vdout0_27ck56 = 1.1 time = 285
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=285.025n

* CHECK dout0_28 Vdout0_28ck56 = 0 time = 285
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=285.025n

* CHECK dout0_29 Vdout0_29ck56 = 1.1 time = 285
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=285.025n

* CHECK dout0_30 Vdout0_30ck56 = 0 time = 285
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=285.025n

* CHECK dout0_31 Vdout0_31ck56 = 1.1 time = 285
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=285.025n

* CHECK dout0_0 Vdout0_0ck57 = 0 time = 290
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=290.025n

* CHECK dout0_1 Vdout0_1ck57 = 1.1 time = 290
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=290.025n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 290
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=290.025n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 290
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=290.025n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 290
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=290.025n

* CHECK dout0_5 Vdout0_5ck57 = 1.1 time = 290
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=290.025n

* CHECK dout0_6 Vdout0_6ck57 = 1.1 time = 290
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=290.025n

* CHECK dout0_7 Vdout0_7ck57 = 1.1 time = 290
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=290.025n

* CHECK dout0_8 Vdout0_8ck57 = 0 time = 290
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=290.025n

* CHECK dout0_9 Vdout0_9ck57 = 1.1 time = 290
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=290.025n

* CHECK dout0_10 Vdout0_10ck57 = 0 time = 290
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=290.025n

* CHECK dout0_11 Vdout0_11ck57 = 1.1 time = 290
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=290.025n

* CHECK dout0_12 Vdout0_12ck57 = 1.1 time = 290
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=290.025n

* CHECK dout0_13 Vdout0_13ck57 = 0 time = 290
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=290.025n

* CHECK dout0_14 Vdout0_14ck57 = 0 time = 290
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=290.025n

* CHECK dout0_15 Vdout0_15ck57 = 0 time = 290
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=290.025n

* CHECK dout0_16 Vdout0_16ck57 = 1.1 time = 290
.meas tran vdout0_16ck57 FIND v(dout0_16) AT=290.025n

* CHECK dout0_17 Vdout0_17ck57 = 1.1 time = 290
.meas tran vdout0_17ck57 FIND v(dout0_17) AT=290.025n

* CHECK dout0_18 Vdout0_18ck57 = 0 time = 290
.meas tran vdout0_18ck57 FIND v(dout0_18) AT=290.025n

* CHECK dout0_19 Vdout0_19ck57 = 0 time = 290
.meas tran vdout0_19ck57 FIND v(dout0_19) AT=290.025n

* CHECK dout0_20 Vdout0_20ck57 = 0 time = 290
.meas tran vdout0_20ck57 FIND v(dout0_20) AT=290.025n

* CHECK dout0_21 Vdout0_21ck57 = 0 time = 290
.meas tran vdout0_21ck57 FIND v(dout0_21) AT=290.025n

* CHECK dout0_22 Vdout0_22ck57 = 1.1 time = 290
.meas tran vdout0_22ck57 FIND v(dout0_22) AT=290.025n

* CHECK dout0_23 Vdout0_23ck57 = 1.1 time = 290
.meas tran vdout0_23ck57 FIND v(dout0_23) AT=290.025n

* CHECK dout0_24 Vdout0_24ck57 = 0 time = 290
.meas tran vdout0_24ck57 FIND v(dout0_24) AT=290.025n

* CHECK dout0_25 Vdout0_25ck57 = 1.1 time = 290
.meas tran vdout0_25ck57 FIND v(dout0_25) AT=290.025n

* CHECK dout0_26 Vdout0_26ck57 = 1.1 time = 290
.meas tran vdout0_26ck57 FIND v(dout0_26) AT=290.025n

* CHECK dout0_27 Vdout0_27ck57 = 1.1 time = 290
.meas tran vdout0_27ck57 FIND v(dout0_27) AT=290.025n

* CHECK dout0_28 Vdout0_28ck57 = 1.1 time = 290
.meas tran vdout0_28ck57 FIND v(dout0_28) AT=290.025n

* CHECK dout0_29 Vdout0_29ck57 = 0 time = 290
.meas tran vdout0_29ck57 FIND v(dout0_29) AT=290.025n

* CHECK dout0_30 Vdout0_30ck57 = 0 time = 290
.meas tran vdout0_30ck57 FIND v(dout0_30) AT=290.025n

* CHECK dout0_31 Vdout0_31ck57 = 1.1 time = 290
.meas tran vdout0_31ck57 FIND v(dout0_31) AT=290.025n

* CHECK dout0_0 Vdout0_0ck58 = 1.1 time = 295
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=295.025n

* CHECK dout0_1 Vdout0_1ck58 = 0 time = 295
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=295.025n

* CHECK dout0_2 Vdout0_2ck58 = 0 time = 295
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=295.025n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 295
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=295.025n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 295
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=295.025n

* CHECK dout0_5 Vdout0_5ck58 = 1.1 time = 295
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=295.025n

* CHECK dout0_6 Vdout0_6ck58 = 1.1 time = 295
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=295.025n

* CHECK dout0_7 Vdout0_7ck58 = 0 time = 295
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=295.025n

* CHECK dout0_8 Vdout0_8ck58 = 0 time = 295
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=295.025n

* CHECK dout0_9 Vdout0_9ck58 = 0 time = 295
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=295.025n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 295
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=295.025n

* CHECK dout0_11 Vdout0_11ck58 = 0 time = 295
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=295.025n

* CHECK dout0_12 Vdout0_12ck58 = 1.1 time = 295
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=295.025n

* CHECK dout0_13 Vdout0_13ck58 = 1.1 time = 295
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=295.025n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 295
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=295.025n

* CHECK dout0_15 Vdout0_15ck58 = 1.1 time = 295
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=295.025n

* CHECK dout0_16 Vdout0_16ck58 = 0 time = 295
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=295.025n

* CHECK dout0_17 Vdout0_17ck58 = 0 time = 295
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=295.025n

* CHECK dout0_18 Vdout0_18ck58 = 1.1 time = 295
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=295.025n

* CHECK dout0_19 Vdout0_19ck58 = 0 time = 295
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=295.025n

* CHECK dout0_20 Vdout0_20ck58 = 0 time = 295
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=295.025n

* CHECK dout0_21 Vdout0_21ck58 = 0 time = 295
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=295.025n

* CHECK dout0_22 Vdout0_22ck58 = 1.1 time = 295
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=295.025n

* CHECK dout0_23 Vdout0_23ck58 = 1.1 time = 295
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=295.025n

* CHECK dout0_24 Vdout0_24ck58 = 1.1 time = 295
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=295.025n

* CHECK dout0_25 Vdout0_25ck58 = 1.1 time = 295
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=295.025n

* CHECK dout0_26 Vdout0_26ck58 = 0 time = 295
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=295.025n

* CHECK dout0_27 Vdout0_27ck58 = 1.1 time = 295
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=295.025n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 295
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=295.025n

* CHECK dout0_29 Vdout0_29ck58 = 0 time = 295
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=295.025n

* CHECK dout0_30 Vdout0_30ck58 = 0 time = 295
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=295.025n

* CHECK dout0_31 Vdout0_31ck58 = 0 time = 295
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=295.025n

* CHECK dout0_0 Vdout0_0ck60 = 1.1 time = 305
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=305.025n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 305
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=305.025n

* CHECK dout0_2 Vdout0_2ck60 = 1.1 time = 305
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=305.025n

* CHECK dout0_3 Vdout0_3ck60 = 1.1 time = 305
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=305.025n

* CHECK dout0_4 Vdout0_4ck60 = 1.1 time = 305
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=305.025n

* CHECK dout0_5 Vdout0_5ck60 = 0 time = 305
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=305.025n

* CHECK dout0_6 Vdout0_6ck60 = 0 time = 305
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=305.025n

* CHECK dout0_7 Vdout0_7ck60 = 1.1 time = 305
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=305.025n

* CHECK dout0_8 Vdout0_8ck60 = 1.1 time = 305
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=305.025n

* CHECK dout0_9 Vdout0_9ck60 = 0 time = 305
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=305.025n

* CHECK dout0_10 Vdout0_10ck60 = 1.1 time = 305
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=305.025n

* CHECK dout0_11 Vdout0_11ck60 = 0 time = 305
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=305.025n

* CHECK dout0_12 Vdout0_12ck60 = 1.1 time = 305
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=305.025n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 305
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=305.025n

* CHECK dout0_14 Vdout0_14ck60 = 0 time = 305
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=305.025n

* CHECK dout0_15 Vdout0_15ck60 = 1.1 time = 305
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=305.025n

* CHECK dout0_16 Vdout0_16ck60 = 1.1 time = 305
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=305.025n

* CHECK dout0_17 Vdout0_17ck60 = 1.1 time = 305
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=305.025n

* CHECK dout0_18 Vdout0_18ck60 = 0 time = 305
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=305.025n

* CHECK dout0_19 Vdout0_19ck60 = 1.1 time = 305
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=305.025n

* CHECK dout0_20 Vdout0_20ck60 = 1.1 time = 305
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=305.025n

* CHECK dout0_21 Vdout0_21ck60 = 0 time = 305
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=305.025n

* CHECK dout0_22 Vdout0_22ck60 = 0 time = 305
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=305.025n

* CHECK dout0_23 Vdout0_23ck60 = 0 time = 305
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=305.025n

* CHECK dout0_24 Vdout0_24ck60 = 1.1 time = 305
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=305.025n

* CHECK dout0_25 Vdout0_25ck60 = 1.1 time = 305
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=305.025n

* CHECK dout0_26 Vdout0_26ck60 = 1.1 time = 305
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=305.025n

* CHECK dout0_27 Vdout0_27ck60 = 1.1 time = 305
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=305.025n

* CHECK dout0_28 Vdout0_28ck60 = 0 time = 305
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=305.025n

* CHECK dout0_29 Vdout0_29ck60 = 1.1 time = 305
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=305.025n

* CHECK dout0_30 Vdout0_30ck60 = 0 time = 305
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=305.025n

* CHECK dout0_31 Vdout0_31ck60 = 1.1 time = 305
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=305.025n

* CHECK dout0_0 Vdout0_0ck63 = 0 time = 320
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=320.025n

* CHECK dout0_1 Vdout0_1ck63 = 1.1 time = 320
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=320.025n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 320
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=320.025n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 320
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=320.025n

* CHECK dout0_4 Vdout0_4ck63 = 1.1 time = 320
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=320.025n

* CHECK dout0_5 Vdout0_5ck63 = 1.1 time = 320
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=320.025n

* CHECK dout0_6 Vdout0_6ck63 = 0 time = 320
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=320.025n

* CHECK dout0_7 Vdout0_7ck63 = 0 time = 320
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=320.025n

* CHECK dout0_8 Vdout0_8ck63 = 0 time = 320
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=320.025n

* CHECK dout0_9 Vdout0_9ck63 = 0 time = 320
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=320.025n

* CHECK dout0_10 Vdout0_10ck63 = 0 time = 320
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=320.025n

* CHECK dout0_11 Vdout0_11ck63 = 1.1 time = 320
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=320.025n

* CHECK dout0_12 Vdout0_12ck63 = 0 time = 320
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=320.025n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 320
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=320.025n

* CHECK dout0_14 Vdout0_14ck63 = 1.1 time = 320
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=320.025n

* CHECK dout0_15 Vdout0_15ck63 = 1.1 time = 320
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=320.025n

* CHECK dout0_16 Vdout0_16ck63 = 0 time = 320
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=320.025n

* CHECK dout0_17 Vdout0_17ck63 = 1.1 time = 320
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=320.025n

* CHECK dout0_18 Vdout0_18ck63 = 1.1 time = 320
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=320.025n

* CHECK dout0_19 Vdout0_19ck63 = 1.1 time = 320
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=320.025n

* CHECK dout0_20 Vdout0_20ck63 = 0 time = 320
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=320.025n

* CHECK dout0_21 Vdout0_21ck63 = 0 time = 320
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=320.025n

* CHECK dout0_22 Vdout0_22ck63 = 0 time = 320
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=320.025n

* CHECK dout0_23 Vdout0_23ck63 = 1.1 time = 320
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=320.025n

* CHECK dout0_24 Vdout0_24ck63 = 1.1 time = 320
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=320.025n

* CHECK dout0_25 Vdout0_25ck63 = 0 time = 320
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=320.025n

* CHECK dout0_26 Vdout0_26ck63 = 0 time = 320
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=320.025n

* CHECK dout0_27 Vdout0_27ck63 = 0 time = 320
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=320.025n

* CHECK dout0_28 Vdout0_28ck63 = 0 time = 320
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=320.025n

* CHECK dout0_29 Vdout0_29ck63 = 1.1 time = 320
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=320.025n

* CHECK dout0_30 Vdout0_30ck63 = 0 time = 320
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=320.025n

* CHECK dout0_31 Vdout0_31ck63 = 0 time = 320
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=320.025n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 335
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=335.025n

* CHECK dout0_1 Vdout0_1ck66 = 1.1 time = 335
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=335.025n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 335
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=335.025n

* CHECK dout0_3 Vdout0_3ck66 = 0 time = 335
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=335.025n

* CHECK dout0_4 Vdout0_4ck66 = 0 time = 335
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=335.025n

* CHECK dout0_5 Vdout0_5ck66 = 1.1 time = 335
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=335.025n

* CHECK dout0_6 Vdout0_6ck66 = 1.1 time = 335
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=335.025n

* CHECK dout0_7 Vdout0_7ck66 = 1.1 time = 335
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=335.025n

* CHECK dout0_8 Vdout0_8ck66 = 0 time = 335
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=335.025n

* CHECK dout0_9 Vdout0_9ck66 = 1.1 time = 335
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=335.025n

* CHECK dout0_10 Vdout0_10ck66 = 0 time = 335
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=335.025n

* CHECK dout0_11 Vdout0_11ck66 = 1.1 time = 335
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=335.025n

* CHECK dout0_12 Vdout0_12ck66 = 1.1 time = 335
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=335.025n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 335
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=335.025n

* CHECK dout0_14 Vdout0_14ck66 = 0 time = 335
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=335.025n

* CHECK dout0_15 Vdout0_15ck66 = 0 time = 335
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=335.025n

* CHECK dout0_16 Vdout0_16ck66 = 1.1 time = 335
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=335.025n

* CHECK dout0_17 Vdout0_17ck66 = 1.1 time = 335
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=335.025n

* CHECK dout0_18 Vdout0_18ck66 = 0 time = 335
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=335.025n

* CHECK dout0_19 Vdout0_19ck66 = 0 time = 335
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=335.025n

* CHECK dout0_20 Vdout0_20ck66 = 0 time = 335
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=335.025n

* CHECK dout0_21 Vdout0_21ck66 = 0 time = 335
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=335.025n

* CHECK dout0_22 Vdout0_22ck66 = 1.1 time = 335
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=335.025n

* CHECK dout0_23 Vdout0_23ck66 = 1.1 time = 335
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=335.025n

* CHECK dout0_24 Vdout0_24ck66 = 0 time = 335
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=335.025n

* CHECK dout0_25 Vdout0_25ck66 = 1.1 time = 335
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=335.025n

* CHECK dout0_26 Vdout0_26ck66 = 1.1 time = 335
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=335.025n

* CHECK dout0_27 Vdout0_27ck66 = 1.1 time = 335
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=335.025n

* CHECK dout0_28 Vdout0_28ck66 = 1.1 time = 335
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=335.025n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 335
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=335.025n

* CHECK dout0_30 Vdout0_30ck66 = 0 time = 335
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=335.025n

* CHECK dout0_31 Vdout0_31ck66 = 1.1 time = 335
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=335.025n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 345
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=345.025n

* CHECK dout0_1 Vdout0_1ck68 = 1.1 time = 345
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=345.025n

* CHECK dout0_2 Vdout0_2ck68 = 0 time = 345
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=345.025n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 345
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=345.025n

* CHECK dout0_4 Vdout0_4ck68 = 1.1 time = 345
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=345.025n

* CHECK dout0_5 Vdout0_5ck68 = 1.1 time = 345
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=345.025n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 345
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=345.025n

* CHECK dout0_7 Vdout0_7ck68 = 0 time = 345
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=345.025n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 345
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=345.025n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 345
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=345.025n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 345
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=345.025n

* CHECK dout0_11 Vdout0_11ck68 = 1.1 time = 345
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=345.025n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 345
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=345.025n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 345
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=345.025n

* CHECK dout0_14 Vdout0_14ck68 = 1.1 time = 345
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=345.025n

* CHECK dout0_15 Vdout0_15ck68 = 1.1 time = 345
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=345.025n

* CHECK dout0_16 Vdout0_16ck68 = 0 time = 345
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=345.025n

* CHECK dout0_17 Vdout0_17ck68 = 1.1 time = 345
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=345.025n

* CHECK dout0_18 Vdout0_18ck68 = 1.1 time = 345
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=345.025n

* CHECK dout0_19 Vdout0_19ck68 = 1.1 time = 345
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=345.025n

* CHECK dout0_20 Vdout0_20ck68 = 0 time = 345
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=345.025n

* CHECK dout0_21 Vdout0_21ck68 = 0 time = 345
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=345.025n

* CHECK dout0_22 Vdout0_22ck68 = 0 time = 345
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=345.025n

* CHECK dout0_23 Vdout0_23ck68 = 1.1 time = 345
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=345.025n

* CHECK dout0_24 Vdout0_24ck68 = 1.1 time = 345
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=345.025n

* CHECK dout0_25 Vdout0_25ck68 = 0 time = 345
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=345.025n

* CHECK dout0_26 Vdout0_26ck68 = 0 time = 345
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=345.025n

* CHECK dout0_27 Vdout0_27ck68 = 0 time = 345
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=345.025n

* CHECK dout0_28 Vdout0_28ck68 = 0 time = 345
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=345.025n

* CHECK dout0_29 Vdout0_29ck68 = 1.1 time = 345
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=345.025n

* CHECK dout0_30 Vdout0_30ck68 = 0 time = 345
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=345.025n

* CHECK dout0_31 Vdout0_31ck68 = 0 time = 345
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=345.025n

* CHECK dout0_0 Vdout0_0ck69 = 0 time = 350
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=350.025n

* CHECK dout0_1 Vdout0_1ck69 = 1.1 time = 350
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=350.025n

* CHECK dout0_2 Vdout0_2ck69 = 0 time = 350
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=350.025n

* CHECK dout0_3 Vdout0_3ck69 = 1.1 time = 350
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=350.025n

* CHECK dout0_4 Vdout0_4ck69 = 1.1 time = 350
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=350.025n

* CHECK dout0_5 Vdout0_5ck69 = 0 time = 350
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=350.025n

* CHECK dout0_6 Vdout0_6ck69 = 0 time = 350
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=350.025n

* CHECK dout0_7 Vdout0_7ck69 = 1.1 time = 350
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=350.025n

* CHECK dout0_8 Vdout0_8ck69 = 0 time = 350
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=350.025n

* CHECK dout0_9 Vdout0_9ck69 = 1.1 time = 350
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=350.025n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 350
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=350.025n

* CHECK dout0_11 Vdout0_11ck69 = 1.1 time = 350
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=350.025n

* CHECK dout0_12 Vdout0_12ck69 = 0 time = 350
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=350.025n

* CHECK dout0_13 Vdout0_13ck69 = 0 time = 350
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=350.025n

* CHECK dout0_14 Vdout0_14ck69 = 1.1 time = 350
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=350.025n

* CHECK dout0_15 Vdout0_15ck69 = 0 time = 350
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=350.025n

* CHECK dout0_16 Vdout0_16ck69 = 1.1 time = 350
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=350.025n

* CHECK dout0_17 Vdout0_17ck69 = 1.1 time = 350
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=350.025n

* CHECK dout0_18 Vdout0_18ck69 = 1.1 time = 350
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=350.025n

* CHECK dout0_19 Vdout0_19ck69 = 1.1 time = 350
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=350.025n

* CHECK dout0_20 Vdout0_20ck69 = 0 time = 350
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=350.025n

* CHECK dout0_21 Vdout0_21ck69 = 0 time = 350
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=350.025n

* CHECK dout0_22 Vdout0_22ck69 = 0 time = 350
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=350.025n

* CHECK dout0_23 Vdout0_23ck69 = 1.1 time = 350
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=350.025n

* CHECK dout0_24 Vdout0_24ck69 = 1.1 time = 350
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=350.025n

* CHECK dout0_25 Vdout0_25ck69 = 0 time = 350
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=350.025n

* CHECK dout0_26 Vdout0_26ck69 = 1.1 time = 350
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=350.025n

* CHECK dout0_27 Vdout0_27ck69 = 1.1 time = 350
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=350.025n

* CHECK dout0_28 Vdout0_28ck69 = 0 time = 350
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=350.025n

* CHECK dout0_29 Vdout0_29ck69 = 1.1 time = 350
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=350.025n

* CHECK dout0_30 Vdout0_30ck69 = 0 time = 350
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=350.025n

* CHECK dout0_31 Vdout0_31ck69 = 1.1 time = 350
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=350.025n

* CHECK dout0_0 Vdout0_0ck71 = 1.1 time = 360
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=360.025n

* CHECK dout0_1 Vdout0_1ck71 = 0 time = 360
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=360.025n

* CHECK dout0_2 Vdout0_2ck71 = 1.1 time = 360
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=360.025n

* CHECK dout0_3 Vdout0_3ck71 = 1.1 time = 360
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=360.025n

* CHECK dout0_4 Vdout0_4ck71 = 1.1 time = 360
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=360.025n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 360
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=360.025n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 360
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=360.025n

* CHECK dout0_7 Vdout0_7ck71 = 1.1 time = 360
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=360.025n

* CHECK dout0_8 Vdout0_8ck71 = 1.1 time = 360
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=360.025n

* CHECK dout0_9 Vdout0_9ck71 = 0 time = 360
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=360.025n

* CHECK dout0_10 Vdout0_10ck71 = 1.1 time = 360
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=360.025n

* CHECK dout0_11 Vdout0_11ck71 = 0 time = 360
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=360.025n

* CHECK dout0_12 Vdout0_12ck71 = 1.1 time = 360
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=360.025n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 360
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=360.025n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 360
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=360.025n

* CHECK dout0_15 Vdout0_15ck71 = 1.1 time = 360
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=360.025n

* CHECK dout0_16 Vdout0_16ck71 = 1.1 time = 360
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=360.025n

* CHECK dout0_17 Vdout0_17ck71 = 1.1 time = 360
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=360.025n

* CHECK dout0_18 Vdout0_18ck71 = 0 time = 360
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=360.025n

* CHECK dout0_19 Vdout0_19ck71 = 1.1 time = 360
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=360.025n

* CHECK dout0_20 Vdout0_20ck71 = 1.1 time = 360
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=360.025n

* CHECK dout0_21 Vdout0_21ck71 = 0 time = 360
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=360.025n

* CHECK dout0_22 Vdout0_22ck71 = 0 time = 360
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=360.025n

* CHECK dout0_23 Vdout0_23ck71 = 0 time = 360
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=360.025n

* CHECK dout0_24 Vdout0_24ck71 = 1.1 time = 360
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=360.025n

* CHECK dout0_25 Vdout0_25ck71 = 1.1 time = 360
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=360.025n

* CHECK dout0_26 Vdout0_26ck71 = 1.1 time = 360
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=360.025n

* CHECK dout0_27 Vdout0_27ck71 = 1.1 time = 360
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=360.025n

* CHECK dout0_28 Vdout0_28ck71 = 0 time = 360
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=360.025n

* CHECK dout0_29 Vdout0_29ck71 = 1.1 time = 360
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=360.025n

* CHECK dout0_30 Vdout0_30ck71 = 0 time = 360
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=360.025n

* CHECK dout0_31 Vdout0_31ck71 = 1.1 time = 360
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=360.025n

* CHECK dout0_0 Vdout0_0ck72 = 1.1 time = 365
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=365.025n

* CHECK dout0_1 Vdout0_1ck72 = 1.1 time = 365
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=365.025n

* CHECK dout0_2 Vdout0_2ck72 = 1.1 time = 365
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=365.025n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 365
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=365.025n

* CHECK dout0_4 Vdout0_4ck72 = 1.1 time = 365
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=365.025n

* CHECK dout0_5 Vdout0_5ck72 = 1.1 time = 365
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=365.025n

* CHECK dout0_6 Vdout0_6ck72 = 1.1 time = 365
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=365.025n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 365
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=365.025n

* CHECK dout0_8 Vdout0_8ck72 = 1.1 time = 365
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=365.025n

* CHECK dout0_9 Vdout0_9ck72 = 0 time = 365
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=365.025n

* CHECK dout0_10 Vdout0_10ck72 = 0 time = 365
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=365.025n

* CHECK dout0_11 Vdout0_11ck72 = 1.1 time = 365
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=365.025n

* CHECK dout0_12 Vdout0_12ck72 = 1.1 time = 365
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=365.025n

* CHECK dout0_13 Vdout0_13ck72 = 1.1 time = 365
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=365.025n

* CHECK dout0_14 Vdout0_14ck72 = 0 time = 365
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=365.025n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 365
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=365.025n

* CHECK dout0_16 Vdout0_16ck72 = 0 time = 365
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=365.025n

* CHECK dout0_17 Vdout0_17ck72 = 0 time = 365
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=365.025n

* CHECK dout0_18 Vdout0_18ck72 = 1.1 time = 365
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=365.025n

* CHECK dout0_19 Vdout0_19ck72 = 1.1 time = 365
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=365.025n

* CHECK dout0_20 Vdout0_20ck72 = 0 time = 365
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=365.025n

* CHECK dout0_21 Vdout0_21ck72 = 0 time = 365
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=365.025n

* CHECK dout0_22 Vdout0_22ck72 = 1.1 time = 365
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=365.025n

* CHECK dout0_23 Vdout0_23ck72 = 1.1 time = 365
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=365.025n

* CHECK dout0_24 Vdout0_24ck72 = 1.1 time = 365
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=365.025n

* CHECK dout0_25 Vdout0_25ck72 = 0 time = 365
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=365.025n

* CHECK dout0_26 Vdout0_26ck72 = 1.1 time = 365
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=365.025n

* CHECK dout0_27 Vdout0_27ck72 = 1.1 time = 365
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=365.025n

* CHECK dout0_28 Vdout0_28ck72 = 1.1 time = 365
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=365.025n

* CHECK dout0_29 Vdout0_29ck72 = 0 time = 365
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=365.025n

* CHECK dout0_30 Vdout0_30ck72 = 1.1 time = 365
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=365.025n

* CHECK dout0_31 Vdout0_31ck72 = 1.1 time = 365
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=365.025n

* CHECK dout0_0 Vdout0_0ck76 = 1.1 time = 385
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=385.025n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 385
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=385.025n

* CHECK dout0_2 Vdout0_2ck76 = 1.1 time = 385
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=385.025n

* CHECK dout0_3 Vdout0_3ck76 = 0 time = 385
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=385.025n

* CHECK dout0_4 Vdout0_4ck76 = 1.1 time = 385
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=385.025n

* CHECK dout0_5 Vdout0_5ck76 = 1.1 time = 385
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=385.025n

* CHECK dout0_6 Vdout0_6ck76 = 1.1 time = 385
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=385.025n

* CHECK dout0_7 Vdout0_7ck76 = 1.1 time = 385
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=385.025n

* CHECK dout0_8 Vdout0_8ck76 = 1.1 time = 385
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=385.025n

* CHECK dout0_9 Vdout0_9ck76 = 0 time = 385
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=385.025n

* CHECK dout0_10 Vdout0_10ck76 = 0 time = 385
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=385.025n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 385
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=385.025n

* CHECK dout0_12 Vdout0_12ck76 = 0 time = 385
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=385.025n

* CHECK dout0_13 Vdout0_13ck76 = 0 time = 385
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=385.025n

* CHECK dout0_14 Vdout0_14ck76 = 1.1 time = 385
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=385.025n

* CHECK dout0_15 Vdout0_15ck76 = 1.1 time = 385
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=385.025n

* CHECK dout0_16 Vdout0_16ck76 = 0 time = 385
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=385.025n

* CHECK dout0_17 Vdout0_17ck76 = 0 time = 385
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=385.025n

* CHECK dout0_18 Vdout0_18ck76 = 1.1 time = 385
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=385.025n

* CHECK dout0_19 Vdout0_19ck76 = 0 time = 385
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=385.025n

* CHECK dout0_20 Vdout0_20ck76 = 1.1 time = 385
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=385.025n

* CHECK dout0_21 Vdout0_21ck76 = 0 time = 385
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=385.025n

* CHECK dout0_22 Vdout0_22ck76 = 0 time = 385
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=385.025n

* CHECK dout0_23 Vdout0_23ck76 = 1.1 time = 385
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=385.025n

* CHECK dout0_24 Vdout0_24ck76 = 1.1 time = 385
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=385.025n

* CHECK dout0_25 Vdout0_25ck76 = 0 time = 385
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=385.025n

* CHECK dout0_26 Vdout0_26ck76 = 1.1 time = 385
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=385.025n

* CHECK dout0_27 Vdout0_27ck76 = 1.1 time = 385
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=385.025n

* CHECK dout0_28 Vdout0_28ck76 = 0 time = 385
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=385.025n

* CHECK dout0_29 Vdout0_29ck76 = 0 time = 385
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=385.025n

* CHECK dout0_30 Vdout0_30ck76 = 1.1 time = 385
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=385.025n

* CHECK dout0_31 Vdout0_31ck76 = 0 time = 385
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=385.025n

* CHECK dout0_0 Vdout0_0ck78 = 1.1 time = 395
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=395.025n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 395
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=395.025n

* CHECK dout0_2 Vdout0_2ck78 = 1.1 time = 395
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=395.025n

* CHECK dout0_3 Vdout0_3ck78 = 0 time = 395
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=395.025n

* CHECK dout0_4 Vdout0_4ck78 = 1.1 time = 395
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=395.025n

* CHECK dout0_5 Vdout0_5ck78 = 1.1 time = 395
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=395.025n

* CHECK dout0_6 Vdout0_6ck78 = 1.1 time = 395
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=395.025n

* CHECK dout0_7 Vdout0_7ck78 = 1.1 time = 395
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=395.025n

* CHECK dout0_8 Vdout0_8ck78 = 1.1 time = 395
.meas tran vdout0_8ck78 FIND v(dout0_8) AT=395.025n

* CHECK dout0_9 Vdout0_9ck78 = 0 time = 395
.meas tran vdout0_9ck78 FIND v(dout0_9) AT=395.025n

* CHECK dout0_10 Vdout0_10ck78 = 0 time = 395
.meas tran vdout0_10ck78 FIND v(dout0_10) AT=395.025n

* CHECK dout0_11 Vdout0_11ck78 = 0 time = 395
.meas tran vdout0_11ck78 FIND v(dout0_11) AT=395.025n

* CHECK dout0_12 Vdout0_12ck78 = 0 time = 395
.meas tran vdout0_12ck78 FIND v(dout0_12) AT=395.025n

* CHECK dout0_13 Vdout0_13ck78 = 0 time = 395
.meas tran vdout0_13ck78 FIND v(dout0_13) AT=395.025n

* CHECK dout0_14 Vdout0_14ck78 = 1.1 time = 395
.meas tran vdout0_14ck78 FIND v(dout0_14) AT=395.025n

* CHECK dout0_15 Vdout0_15ck78 = 1.1 time = 395
.meas tran vdout0_15ck78 FIND v(dout0_15) AT=395.025n

* CHECK dout0_16 Vdout0_16ck78 = 0 time = 395
.meas tran vdout0_16ck78 FIND v(dout0_16) AT=395.025n

* CHECK dout0_17 Vdout0_17ck78 = 0 time = 395
.meas tran vdout0_17ck78 FIND v(dout0_17) AT=395.025n

* CHECK dout0_18 Vdout0_18ck78 = 1.1 time = 395
.meas tran vdout0_18ck78 FIND v(dout0_18) AT=395.025n

* CHECK dout0_19 Vdout0_19ck78 = 0 time = 395
.meas tran vdout0_19ck78 FIND v(dout0_19) AT=395.025n

* CHECK dout0_20 Vdout0_20ck78 = 1.1 time = 395
.meas tran vdout0_20ck78 FIND v(dout0_20) AT=395.025n

* CHECK dout0_21 Vdout0_21ck78 = 0 time = 395
.meas tran vdout0_21ck78 FIND v(dout0_21) AT=395.025n

* CHECK dout0_22 Vdout0_22ck78 = 0 time = 395
.meas tran vdout0_22ck78 FIND v(dout0_22) AT=395.025n

* CHECK dout0_23 Vdout0_23ck78 = 1.1 time = 395
.meas tran vdout0_23ck78 FIND v(dout0_23) AT=395.025n

* CHECK dout0_24 Vdout0_24ck78 = 1.1 time = 395
.meas tran vdout0_24ck78 FIND v(dout0_24) AT=395.025n

* CHECK dout0_25 Vdout0_25ck78 = 0 time = 395
.meas tran vdout0_25ck78 FIND v(dout0_25) AT=395.025n

* CHECK dout0_26 Vdout0_26ck78 = 1.1 time = 395
.meas tran vdout0_26ck78 FIND v(dout0_26) AT=395.025n

* CHECK dout0_27 Vdout0_27ck78 = 1.1 time = 395
.meas tran vdout0_27ck78 FIND v(dout0_27) AT=395.025n

* CHECK dout0_28 Vdout0_28ck78 = 0 time = 395
.meas tran vdout0_28ck78 FIND v(dout0_28) AT=395.025n

* CHECK dout0_29 Vdout0_29ck78 = 0 time = 395
.meas tran vdout0_29ck78 FIND v(dout0_29) AT=395.025n

* CHECK dout0_30 Vdout0_30ck78 = 1.1 time = 395
.meas tran vdout0_30ck78 FIND v(dout0_30) AT=395.025n

* CHECK dout0_31 Vdout0_31ck78 = 0 time = 395
.meas tran vdout0_31ck78 FIND v(dout0_31) AT=395.025n

* CHECK dout0_0 Vdout0_0ck79 = 1.1 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 1.1 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 1.1 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 1.1 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 1.1 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 1.1 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 1.1 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 1.1 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 0 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 0 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 1.1 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 1.1 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 0 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 1.1 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 0 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 0 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 0 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 0 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 1.1 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_0 Vdout0_0ck83 = 1.1 time = 420
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=420.025n

* CHECK dout0_1 Vdout0_1ck83 = 1.1 time = 420
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=420.025n

* CHECK dout0_2 Vdout0_2ck83 = 1.1 time = 420
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=420.025n

* CHECK dout0_3 Vdout0_3ck83 = 0 time = 420
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=420.025n

* CHECK dout0_4 Vdout0_4ck83 = 1.1 time = 420
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=420.025n

* CHECK dout0_5 Vdout0_5ck83 = 1.1 time = 420
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=420.025n

* CHECK dout0_6 Vdout0_6ck83 = 0 time = 420
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=420.025n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 420
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=420.025n

* CHECK dout0_8 Vdout0_8ck83 = 1.1 time = 420
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=420.025n

* CHECK dout0_9 Vdout0_9ck83 = 1.1 time = 420
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=420.025n

* CHECK dout0_10 Vdout0_10ck83 = 1.1 time = 420
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=420.025n

* CHECK dout0_11 Vdout0_11ck83 = 1.1 time = 420
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=420.025n

* CHECK dout0_12 Vdout0_12ck83 = 1.1 time = 420
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=420.025n

* CHECK dout0_13 Vdout0_13ck83 = 1.1 time = 420
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=420.025n

* CHECK dout0_14 Vdout0_14ck83 = 1.1 time = 420
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=420.025n

* CHECK dout0_15 Vdout0_15ck83 = 0 time = 420
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=420.025n

* CHECK dout0_16 Vdout0_16ck83 = 0 time = 420
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=420.025n

* CHECK dout0_17 Vdout0_17ck83 = 0 time = 420
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=420.025n

* CHECK dout0_18 Vdout0_18ck83 = 1.1 time = 420
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=420.025n

* CHECK dout0_19 Vdout0_19ck83 = 0 time = 420
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=420.025n

* CHECK dout0_20 Vdout0_20ck83 = 0 time = 420
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=420.025n

* CHECK dout0_21 Vdout0_21ck83 = 0 time = 420
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=420.025n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 420
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=420.025n

* CHECK dout0_23 Vdout0_23ck83 = 0 time = 420
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=420.025n

* CHECK dout0_24 Vdout0_24ck83 = 1.1 time = 420
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=420.025n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 420
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=420.025n

* CHECK dout0_26 Vdout0_26ck83 = 1.1 time = 420
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=420.025n

* CHECK dout0_27 Vdout0_27ck83 = 1.1 time = 420
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=420.025n

* CHECK dout0_28 Vdout0_28ck83 = 0 time = 420
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=420.025n

* CHECK dout0_29 Vdout0_29ck83 = 1.1 time = 420
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=420.025n

* CHECK dout0_30 Vdout0_30ck83 = 0 time = 420
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=420.025n

* CHECK dout0_31 Vdout0_31ck83 = 1.1 time = 420
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=420.025n

* CHECK dout0_0 Vdout0_0ck85 = 1.1 time = 430
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=430.025n

* CHECK dout0_1 Vdout0_1ck85 = 1.1 time = 430
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=430.025n

* CHECK dout0_2 Vdout0_2ck85 = 1.1 time = 430
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=430.025n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 430
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=430.025n

* CHECK dout0_4 Vdout0_4ck85 = 1.1 time = 430
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=430.025n

* CHECK dout0_5 Vdout0_5ck85 = 1.1 time = 430
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=430.025n

* CHECK dout0_6 Vdout0_6ck85 = 0 time = 430
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=430.025n

* CHECK dout0_7 Vdout0_7ck85 = 0 time = 430
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=430.025n

* CHECK dout0_8 Vdout0_8ck85 = 1.1 time = 430
.meas tran vdout0_8ck85 FIND v(dout0_8) AT=430.025n

* CHECK dout0_9 Vdout0_9ck85 = 1.1 time = 430
.meas tran vdout0_9ck85 FIND v(dout0_9) AT=430.025n

* CHECK dout0_10 Vdout0_10ck85 = 1.1 time = 430
.meas tran vdout0_10ck85 FIND v(dout0_10) AT=430.025n

* CHECK dout0_11 Vdout0_11ck85 = 1.1 time = 430
.meas tran vdout0_11ck85 FIND v(dout0_11) AT=430.025n

* CHECK dout0_12 Vdout0_12ck85 = 1.1 time = 430
.meas tran vdout0_12ck85 FIND v(dout0_12) AT=430.025n

* CHECK dout0_13 Vdout0_13ck85 = 1.1 time = 430
.meas tran vdout0_13ck85 FIND v(dout0_13) AT=430.025n

* CHECK dout0_14 Vdout0_14ck85 = 1.1 time = 430
.meas tran vdout0_14ck85 FIND v(dout0_14) AT=430.025n

* CHECK dout0_15 Vdout0_15ck85 = 0 time = 430
.meas tran vdout0_15ck85 FIND v(dout0_15) AT=430.025n

* CHECK dout0_16 Vdout0_16ck85 = 0 time = 430
.meas tran vdout0_16ck85 FIND v(dout0_16) AT=430.025n

* CHECK dout0_17 Vdout0_17ck85 = 0 time = 430
.meas tran vdout0_17ck85 FIND v(dout0_17) AT=430.025n

* CHECK dout0_18 Vdout0_18ck85 = 1.1 time = 430
.meas tran vdout0_18ck85 FIND v(dout0_18) AT=430.025n

* CHECK dout0_19 Vdout0_19ck85 = 0 time = 430
.meas tran vdout0_19ck85 FIND v(dout0_19) AT=430.025n

* CHECK dout0_20 Vdout0_20ck85 = 0 time = 430
.meas tran vdout0_20ck85 FIND v(dout0_20) AT=430.025n

* CHECK dout0_21 Vdout0_21ck85 = 0 time = 430
.meas tran vdout0_21ck85 FIND v(dout0_21) AT=430.025n

* CHECK dout0_22 Vdout0_22ck85 = 0 time = 430
.meas tran vdout0_22ck85 FIND v(dout0_22) AT=430.025n

* CHECK dout0_23 Vdout0_23ck85 = 0 time = 430
.meas tran vdout0_23ck85 FIND v(dout0_23) AT=430.025n

* CHECK dout0_24 Vdout0_24ck85 = 1.1 time = 430
.meas tran vdout0_24ck85 FIND v(dout0_24) AT=430.025n

* CHECK dout0_25 Vdout0_25ck85 = 0 time = 430
.meas tran vdout0_25ck85 FIND v(dout0_25) AT=430.025n

* CHECK dout0_26 Vdout0_26ck85 = 1.1 time = 430
.meas tran vdout0_26ck85 FIND v(dout0_26) AT=430.025n

* CHECK dout0_27 Vdout0_27ck85 = 1.1 time = 430
.meas tran vdout0_27ck85 FIND v(dout0_27) AT=430.025n

* CHECK dout0_28 Vdout0_28ck85 = 0 time = 430
.meas tran vdout0_28ck85 FIND v(dout0_28) AT=430.025n

* CHECK dout0_29 Vdout0_29ck85 = 1.1 time = 430
.meas tran vdout0_29ck85 FIND v(dout0_29) AT=430.025n

* CHECK dout0_30 Vdout0_30ck85 = 0 time = 430
.meas tran vdout0_30ck85 FIND v(dout0_30) AT=430.025n

* CHECK dout0_31 Vdout0_31ck85 = 1.1 time = 430
.meas tran vdout0_31ck85 FIND v(dout0_31) AT=430.025n

* CHECK dout0_0 Vdout0_0ck87 = 1.1 time = 440
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=440.025n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 440
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=440.025n

* CHECK dout0_2 Vdout0_2ck87 = 1.1 time = 440
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=440.025n

* CHECK dout0_3 Vdout0_3ck87 = 1.1 time = 440
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=440.025n

* CHECK dout0_4 Vdout0_4ck87 = 1.1 time = 440
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=440.025n

* CHECK dout0_5 Vdout0_5ck87 = 0 time = 440
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=440.025n

* CHECK dout0_6 Vdout0_6ck87 = 0 time = 440
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=440.025n

* CHECK dout0_7 Vdout0_7ck87 = 1.1 time = 440
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=440.025n

* CHECK dout0_8 Vdout0_8ck87 = 1.1 time = 440
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=440.025n

* CHECK dout0_9 Vdout0_9ck87 = 0 time = 440
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=440.025n

* CHECK dout0_10 Vdout0_10ck87 = 0 time = 440
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=440.025n

* CHECK dout0_11 Vdout0_11ck87 = 1.1 time = 440
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=440.025n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 440
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=440.025n

* CHECK dout0_13 Vdout0_13ck87 = 0 time = 440
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=440.025n

* CHECK dout0_14 Vdout0_14ck87 = 0 time = 440
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=440.025n

* CHECK dout0_15 Vdout0_15ck87 = 1.1 time = 440
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=440.025n

* CHECK dout0_16 Vdout0_16ck87 = 1.1 time = 440
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=440.025n

* CHECK dout0_17 Vdout0_17ck87 = 0 time = 440
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=440.025n

* CHECK dout0_18 Vdout0_18ck87 = 1.1 time = 440
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=440.025n

* CHECK dout0_19 Vdout0_19ck87 = 1.1 time = 440
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=440.025n

* CHECK dout0_20 Vdout0_20ck87 = 0 time = 440
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=440.025n

* CHECK dout0_21 Vdout0_21ck87 = 1.1 time = 440
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=440.025n

* CHECK dout0_22 Vdout0_22ck87 = 0 time = 440
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=440.025n

* CHECK dout0_23 Vdout0_23ck87 = 0 time = 440
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=440.025n

* CHECK dout0_24 Vdout0_24ck87 = 0 time = 440
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=440.025n

* CHECK dout0_25 Vdout0_25ck87 = 1.1 time = 440
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=440.025n

* CHECK dout0_26 Vdout0_26ck87 = 1.1 time = 440
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=440.025n

* CHECK dout0_27 Vdout0_27ck87 = 1.1 time = 440
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=440.025n

* CHECK dout0_28 Vdout0_28ck87 = 1.1 time = 440
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=440.025n

* CHECK dout0_29 Vdout0_29ck87 = 0 time = 440
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=440.025n

* CHECK dout0_30 Vdout0_30ck87 = 1.1 time = 440
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=440.025n

* CHECK dout0_31 Vdout0_31ck87 = 1.1 time = 440
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=440.025n

* CHECK dout0_0 Vdout0_0ck90 = 0 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 1.1 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 0 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 1.1 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 1.1 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 1.1 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 0 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 1.1 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 1.1 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 1.1 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 0 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 1.1 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 1.1 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 0 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 0 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 1.1 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 1.1 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 0 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 1.1 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 1.1 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 1.1 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 1.1 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 1.1 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 1.1 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 0 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 1.1 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 1.1 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 1.1 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 1.1 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 1.1 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 1.1 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 1.1 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 0 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 1.1 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 0 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 1.1 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 0 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 0 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 1.1 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 1.1 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 1.1 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 0 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 0 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 1.1 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 0 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 0 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 0 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 1.1 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 1.1 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_0 Vdout0_0ck96 = 1.1 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 0 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 1.1 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 1.1 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 1.1 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 1.1 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 1.1 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 1.1 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 1.1 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 0 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 1.1 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 1.1 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 0 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 1.1 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 0 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 0 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 1.1 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 0 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 490
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=490.025n

* CHECK dout0_1 Vdout0_1ck97 = 1.1 time = 490
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=490.025n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 490
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=490.025n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 490
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=490.025n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 490
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=490.025n

* CHECK dout0_5 Vdout0_5ck97 = 1.1 time = 490
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=490.025n

* CHECK dout0_6 Vdout0_6ck97 = 1.1 time = 490
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=490.025n

* CHECK dout0_7 Vdout0_7ck97 = 1.1 time = 490
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=490.025n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 490
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=490.025n

* CHECK dout0_9 Vdout0_9ck97 = 1.1 time = 490
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=490.025n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 490
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=490.025n

* CHECK dout0_11 Vdout0_11ck97 = 1.1 time = 490
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=490.025n

* CHECK dout0_12 Vdout0_12ck97 = 1.1 time = 490
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=490.025n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 490
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=490.025n

* CHECK dout0_14 Vdout0_14ck97 = 0 time = 490
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=490.025n

* CHECK dout0_15 Vdout0_15ck97 = 0 time = 490
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=490.025n

* CHECK dout0_16 Vdout0_16ck97 = 1.1 time = 490
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=490.025n

* CHECK dout0_17 Vdout0_17ck97 = 1.1 time = 490
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=490.025n

* CHECK dout0_18 Vdout0_18ck97 = 0 time = 490
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=490.025n

* CHECK dout0_19 Vdout0_19ck97 = 0 time = 490
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=490.025n

* CHECK dout0_20 Vdout0_20ck97 = 0 time = 490
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=490.025n

* CHECK dout0_21 Vdout0_21ck97 = 0 time = 490
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=490.025n

* CHECK dout0_22 Vdout0_22ck97 = 1.1 time = 490
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=490.025n

* CHECK dout0_23 Vdout0_23ck97 = 1.1 time = 490
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=490.025n

* CHECK dout0_24 Vdout0_24ck97 = 0 time = 490
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=490.025n

* CHECK dout0_25 Vdout0_25ck97 = 1.1 time = 490
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=490.025n

* CHECK dout0_26 Vdout0_26ck97 = 1.1 time = 490
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=490.025n

* CHECK dout0_27 Vdout0_27ck97 = 1.1 time = 490
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=490.025n

* CHECK dout0_28 Vdout0_28ck97 = 1.1 time = 490
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=490.025n

* CHECK dout0_29 Vdout0_29ck97 = 0 time = 490
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=490.025n

* CHECK dout0_30 Vdout0_30ck97 = 0 time = 490
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=490.025n

* CHECK dout0_31 Vdout0_31ck97 = 1.1 time = 490
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=490.025n

* CHECK dout0_0 Vdout0_0ck98 = 1.1 time = 495
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=495.025n

* CHECK dout0_1 Vdout0_1ck98 = 0 time = 495
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=495.025n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 495
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=495.025n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 495
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=495.025n

* CHECK dout0_4 Vdout0_4ck98 = 0 time = 495
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=495.025n

* CHECK dout0_5 Vdout0_5ck98 = 1.1 time = 495
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=495.025n

* CHECK dout0_6 Vdout0_6ck98 = 1.1 time = 495
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=495.025n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 495
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=495.025n

* CHECK dout0_8 Vdout0_8ck98 = 0 time = 495
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=495.025n

* CHECK dout0_9 Vdout0_9ck98 = 0 time = 495
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=495.025n

* CHECK dout0_10 Vdout0_10ck98 = 0 time = 495
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=495.025n

* CHECK dout0_11 Vdout0_11ck98 = 0 time = 495
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=495.025n

* CHECK dout0_12 Vdout0_12ck98 = 1.1 time = 495
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=495.025n

* CHECK dout0_13 Vdout0_13ck98 = 1.1 time = 495
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=495.025n

* CHECK dout0_14 Vdout0_14ck98 = 0 time = 495
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=495.025n

* CHECK dout0_15 Vdout0_15ck98 = 1.1 time = 495
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=495.025n

* CHECK dout0_16 Vdout0_16ck98 = 0 time = 495
.meas tran vdout0_16ck98 FIND v(dout0_16) AT=495.025n

* CHECK dout0_17 Vdout0_17ck98 = 0 time = 495
.meas tran vdout0_17ck98 FIND v(dout0_17) AT=495.025n

* CHECK dout0_18 Vdout0_18ck98 = 1.1 time = 495
.meas tran vdout0_18ck98 FIND v(dout0_18) AT=495.025n

* CHECK dout0_19 Vdout0_19ck98 = 0 time = 495
.meas tran vdout0_19ck98 FIND v(dout0_19) AT=495.025n

* CHECK dout0_20 Vdout0_20ck98 = 0 time = 495
.meas tran vdout0_20ck98 FIND v(dout0_20) AT=495.025n

* CHECK dout0_21 Vdout0_21ck98 = 0 time = 495
.meas tran vdout0_21ck98 FIND v(dout0_21) AT=495.025n

* CHECK dout0_22 Vdout0_22ck98 = 1.1 time = 495
.meas tran vdout0_22ck98 FIND v(dout0_22) AT=495.025n

* CHECK dout0_23 Vdout0_23ck98 = 1.1 time = 495
.meas tran vdout0_23ck98 FIND v(dout0_23) AT=495.025n

* CHECK dout0_24 Vdout0_24ck98 = 1.1 time = 495
.meas tran vdout0_24ck98 FIND v(dout0_24) AT=495.025n

* CHECK dout0_25 Vdout0_25ck98 = 1.1 time = 495
.meas tran vdout0_25ck98 FIND v(dout0_25) AT=495.025n

* CHECK dout0_26 Vdout0_26ck98 = 0 time = 495
.meas tran vdout0_26ck98 FIND v(dout0_26) AT=495.025n

* CHECK dout0_27 Vdout0_27ck98 = 1.1 time = 495
.meas tran vdout0_27ck98 FIND v(dout0_27) AT=495.025n

* CHECK dout0_28 Vdout0_28ck98 = 0 time = 495
.meas tran vdout0_28ck98 FIND v(dout0_28) AT=495.025n

* CHECK dout0_29 Vdout0_29ck98 = 0 time = 495
.meas tran vdout0_29ck98 FIND v(dout0_29) AT=495.025n

* CHECK dout0_30 Vdout0_30ck98 = 0 time = 495
.meas tran vdout0_30ck98 FIND v(dout0_30) AT=495.025n

* CHECK dout0_31 Vdout0_31ck98 = 0 time = 495
.meas tran vdout0_31ck98 FIND v(dout0_31) AT=495.025n

* CHECK dout0_0 Vdout0_0ck99 = 1.1 time = 500
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=500.025n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 500
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=500.025n

* CHECK dout0_2 Vdout0_2ck99 = 1.1 time = 500
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=500.025n

* CHECK dout0_3 Vdout0_3ck99 = 1.1 time = 500
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=500.025n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 500
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=500.025n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 500
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=500.025n

* CHECK dout0_6 Vdout0_6ck99 = 1.1 time = 500
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=500.025n

* CHECK dout0_7 Vdout0_7ck99 = 1.1 time = 500
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=500.025n

* CHECK dout0_8 Vdout0_8ck99 = 0 time = 500
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=500.025n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 500
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=500.025n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 500
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=500.025n

* CHECK dout0_11 Vdout0_11ck99 = 1.1 time = 500
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=500.025n

* CHECK dout0_12 Vdout0_12ck99 = 1.1 time = 500
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=500.025n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 500
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=500.025n

* CHECK dout0_14 Vdout0_14ck99 = 1.1 time = 500
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=500.025n

* CHECK dout0_15 Vdout0_15ck99 = 0 time = 500
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=500.025n

* CHECK dout0_16 Vdout0_16ck99 = 0 time = 500
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=500.025n

* CHECK dout0_17 Vdout0_17ck99 = 1.1 time = 500
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=500.025n

* CHECK dout0_18 Vdout0_18ck99 = 0 time = 500
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=500.025n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 500
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=500.025n

* CHECK dout0_20 Vdout0_20ck99 = 1.1 time = 500
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=500.025n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 500
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=500.025n

* CHECK dout0_22 Vdout0_22ck99 = 1.1 time = 500
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=500.025n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 500
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=500.025n

* CHECK dout0_24 Vdout0_24ck99 = 0 time = 500
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=500.025n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 500
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=500.025n

* CHECK dout0_26 Vdout0_26ck99 = 0 time = 500
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=500.025n

* CHECK dout0_27 Vdout0_27ck99 = 0 time = 500
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=500.025n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 500
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=500.025n

* CHECK dout0_29 Vdout0_29ck99 = 0 time = 500
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=500.025n

* CHECK dout0_30 Vdout0_30ck99 = 1.1 time = 500
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=500.025n

* CHECK dout0_31 Vdout0_31ck99 = 0 time = 500
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=500.025n

* CHECK dout0_0 Vdout0_0ck101 = 1.1 time = 510
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=510.025n

* CHECK dout0_1 Vdout0_1ck101 = 0 time = 510
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=510.025n

* CHECK dout0_2 Vdout0_2ck101 = 1.1 time = 510
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=510.025n

* CHECK dout0_3 Vdout0_3ck101 = 1.1 time = 510
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=510.025n

* CHECK dout0_4 Vdout0_4ck101 = 1.1 time = 510
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=510.025n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 510
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=510.025n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 510
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=510.025n

* CHECK dout0_7 Vdout0_7ck101 = 1.1 time = 510
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=510.025n

* CHECK dout0_8 Vdout0_8ck101 = 1.1 time = 510
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=510.025n

* CHECK dout0_9 Vdout0_9ck101 = 0 time = 510
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=510.025n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 510
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=510.025n

* CHECK dout0_11 Vdout0_11ck101 = 1.1 time = 510
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=510.025n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 510
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=510.025n

* CHECK dout0_13 Vdout0_13ck101 = 0 time = 510
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=510.025n

* CHECK dout0_14 Vdout0_14ck101 = 0 time = 510
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=510.025n

* CHECK dout0_15 Vdout0_15ck101 = 1.1 time = 510
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=510.025n

* CHECK dout0_16 Vdout0_16ck101 = 1.1 time = 510
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=510.025n

* CHECK dout0_17 Vdout0_17ck101 = 0 time = 510
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=510.025n

* CHECK dout0_18 Vdout0_18ck101 = 1.1 time = 510
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=510.025n

* CHECK dout0_19 Vdout0_19ck101 = 1.1 time = 510
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=510.025n

* CHECK dout0_20 Vdout0_20ck101 = 0 time = 510
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=510.025n

* CHECK dout0_21 Vdout0_21ck101 = 1.1 time = 510
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=510.025n

* CHECK dout0_22 Vdout0_22ck101 = 0 time = 510
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=510.025n

* CHECK dout0_23 Vdout0_23ck101 = 0 time = 510
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=510.025n

* CHECK dout0_24 Vdout0_24ck101 = 0 time = 510
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=510.025n

* CHECK dout0_25 Vdout0_25ck101 = 1.1 time = 510
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=510.025n

* CHECK dout0_26 Vdout0_26ck101 = 1.1 time = 510
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=510.025n

* CHECK dout0_27 Vdout0_27ck101 = 1.1 time = 510
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=510.025n

* CHECK dout0_28 Vdout0_28ck101 = 1.1 time = 510
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=510.025n

* CHECK dout0_29 Vdout0_29ck101 = 0 time = 510
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=510.025n

* CHECK dout0_30 Vdout0_30ck101 = 1.1 time = 510
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=510.025n

* CHECK dout0_31 Vdout0_31ck101 = 1.1 time = 510
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=510.025n

* CHECK dout0_0 Vdout0_0ck104 = 1.1 time = 525
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=525.025n

* CHECK dout0_1 Vdout0_1ck104 = 0 time = 525
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=525.025n

* CHECK dout0_2 Vdout0_2ck104 = 0 time = 525
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=525.025n

* CHECK dout0_3 Vdout0_3ck104 = 0 time = 525
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=525.025n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 525
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=525.025n

* CHECK dout0_5 Vdout0_5ck104 = 1.1 time = 525
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=525.025n

* CHECK dout0_6 Vdout0_6ck104 = 1.1 time = 525
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=525.025n

* CHECK dout0_7 Vdout0_7ck104 = 0 time = 525
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=525.025n

* CHECK dout0_8 Vdout0_8ck104 = 0 time = 525
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=525.025n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 525
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=525.025n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 525
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=525.025n

* CHECK dout0_11 Vdout0_11ck104 = 0 time = 525
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=525.025n

* CHECK dout0_12 Vdout0_12ck104 = 1.1 time = 525
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=525.025n

* CHECK dout0_13 Vdout0_13ck104 = 1.1 time = 525
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=525.025n

* CHECK dout0_14 Vdout0_14ck104 = 0 time = 525
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=525.025n

* CHECK dout0_15 Vdout0_15ck104 = 1.1 time = 525
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=525.025n

* CHECK dout0_16 Vdout0_16ck104 = 0 time = 525
.meas tran vdout0_16ck104 FIND v(dout0_16) AT=525.025n

* CHECK dout0_17 Vdout0_17ck104 = 0 time = 525
.meas tran vdout0_17ck104 FIND v(dout0_17) AT=525.025n

* CHECK dout0_18 Vdout0_18ck104 = 1.1 time = 525
.meas tran vdout0_18ck104 FIND v(dout0_18) AT=525.025n

* CHECK dout0_19 Vdout0_19ck104 = 0 time = 525
.meas tran vdout0_19ck104 FIND v(dout0_19) AT=525.025n

* CHECK dout0_20 Vdout0_20ck104 = 0 time = 525
.meas tran vdout0_20ck104 FIND v(dout0_20) AT=525.025n

* CHECK dout0_21 Vdout0_21ck104 = 0 time = 525
.meas tran vdout0_21ck104 FIND v(dout0_21) AT=525.025n

* CHECK dout0_22 Vdout0_22ck104 = 1.1 time = 525
.meas tran vdout0_22ck104 FIND v(dout0_22) AT=525.025n

* CHECK dout0_23 Vdout0_23ck104 = 1.1 time = 525
.meas tran vdout0_23ck104 FIND v(dout0_23) AT=525.025n

* CHECK dout0_24 Vdout0_24ck104 = 1.1 time = 525
.meas tran vdout0_24ck104 FIND v(dout0_24) AT=525.025n

* CHECK dout0_25 Vdout0_25ck104 = 1.1 time = 525
.meas tran vdout0_25ck104 FIND v(dout0_25) AT=525.025n

* CHECK dout0_26 Vdout0_26ck104 = 0 time = 525
.meas tran vdout0_26ck104 FIND v(dout0_26) AT=525.025n

* CHECK dout0_27 Vdout0_27ck104 = 1.1 time = 525
.meas tran vdout0_27ck104 FIND v(dout0_27) AT=525.025n

* CHECK dout0_28 Vdout0_28ck104 = 0 time = 525
.meas tran vdout0_28ck104 FIND v(dout0_28) AT=525.025n

* CHECK dout0_29 Vdout0_29ck104 = 0 time = 525
.meas tran vdout0_29ck104 FIND v(dout0_29) AT=525.025n

* CHECK dout0_30 Vdout0_30ck104 = 0 time = 525
.meas tran vdout0_30ck104 FIND v(dout0_30) AT=525.025n

* CHECK dout0_31 Vdout0_31ck104 = 0 time = 525
.meas tran vdout0_31ck104 FIND v(dout0_31) AT=525.025n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 0 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 1.1 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 0 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 0 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 1.1 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 1.1 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 0 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 1.1 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 1.1 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 0 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 1.1 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 0 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 1.1 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 0 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 1.1 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 0 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 0 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 0 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 0 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 0 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 1.1 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 0 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 0 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 1.1 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 0 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_0 Vdout0_0ck108 = 1.1 time = 545
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=545.025n

* CHECK dout0_1 Vdout0_1ck108 = 1.1 time = 545
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=545.025n

* CHECK dout0_2 Vdout0_2ck108 = 1.1 time = 545
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=545.025n

* CHECK dout0_3 Vdout0_3ck108 = 0 time = 545
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=545.025n

* CHECK dout0_4 Vdout0_4ck108 = 1.1 time = 545
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=545.025n

* CHECK dout0_5 Vdout0_5ck108 = 1.1 time = 545
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=545.025n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 545
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=545.025n

* CHECK dout0_7 Vdout0_7ck108 = 0 time = 545
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=545.025n

* CHECK dout0_8 Vdout0_8ck108 = 1.1 time = 545
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=545.025n

* CHECK dout0_9 Vdout0_9ck108 = 1.1 time = 545
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=545.025n

* CHECK dout0_10 Vdout0_10ck108 = 1.1 time = 545
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=545.025n

* CHECK dout0_11 Vdout0_11ck108 = 1.1 time = 545
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=545.025n

* CHECK dout0_12 Vdout0_12ck108 = 1.1 time = 545
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=545.025n

* CHECK dout0_13 Vdout0_13ck108 = 1.1 time = 545
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=545.025n

* CHECK dout0_14 Vdout0_14ck108 = 1.1 time = 545
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=545.025n

* CHECK dout0_15 Vdout0_15ck108 = 0 time = 545
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=545.025n

* CHECK dout0_16 Vdout0_16ck108 = 0 time = 545
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=545.025n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 545
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=545.025n

* CHECK dout0_18 Vdout0_18ck108 = 1.1 time = 545
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=545.025n

* CHECK dout0_19 Vdout0_19ck108 = 0 time = 545
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=545.025n

* CHECK dout0_20 Vdout0_20ck108 = 0 time = 545
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=545.025n

* CHECK dout0_21 Vdout0_21ck108 = 0 time = 545
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=545.025n

* CHECK dout0_22 Vdout0_22ck108 = 0 time = 545
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=545.025n

* CHECK dout0_23 Vdout0_23ck108 = 0 time = 545
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=545.025n

* CHECK dout0_24 Vdout0_24ck108 = 1.1 time = 545
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=545.025n

* CHECK dout0_25 Vdout0_25ck108 = 0 time = 545
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=545.025n

* CHECK dout0_26 Vdout0_26ck108 = 1.1 time = 545
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=545.025n

* CHECK dout0_27 Vdout0_27ck108 = 1.1 time = 545
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=545.025n

* CHECK dout0_28 Vdout0_28ck108 = 0 time = 545
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=545.025n

* CHECK dout0_29 Vdout0_29ck108 = 1.1 time = 545
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=545.025n

* CHECK dout0_30 Vdout0_30ck108 = 0 time = 545
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=545.025n

* CHECK dout0_31 Vdout0_31ck108 = 1.1 time = 545
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=545.025n

* CHECK dout0_0 Vdout0_0ck109 = 0 time = 550
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=550.025n

* CHECK dout0_1 Vdout0_1ck109 = 0 time = 550
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=550.025n

* CHECK dout0_2 Vdout0_2ck109 = 1.1 time = 550
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=550.025n

* CHECK dout0_3 Vdout0_3ck109 = 0 time = 550
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=550.025n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 550
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=550.025n

* CHECK dout0_5 Vdout0_5ck109 = 0 time = 550
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=550.025n

* CHECK dout0_6 Vdout0_6ck109 = 1.1 time = 550
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=550.025n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 550
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=550.025n

* CHECK dout0_8 Vdout0_8ck109 = 1.1 time = 550
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=550.025n

* CHECK dout0_9 Vdout0_9ck109 = 0 time = 550
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=550.025n

* CHECK dout0_10 Vdout0_10ck109 = 1.1 time = 550
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=550.025n

* CHECK dout0_11 Vdout0_11ck109 = 0 time = 550
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=550.025n

* CHECK dout0_12 Vdout0_12ck109 = 1.1 time = 550
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=550.025n

* CHECK dout0_13 Vdout0_13ck109 = 0 time = 550
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=550.025n

* CHECK dout0_14 Vdout0_14ck109 = 1.1 time = 550
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=550.025n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 550
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=550.025n

* CHECK dout0_16 Vdout0_16ck109 = 1.1 time = 550
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=550.025n

* CHECK dout0_17 Vdout0_17ck109 = 0 time = 550
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=550.025n

* CHECK dout0_18 Vdout0_18ck109 = 1.1 time = 550
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=550.025n

* CHECK dout0_19 Vdout0_19ck109 = 0 time = 550
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=550.025n

* CHECK dout0_20 Vdout0_20ck109 = 0 time = 550
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=550.025n

* CHECK dout0_21 Vdout0_21ck109 = 0 time = 550
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=550.025n

* CHECK dout0_22 Vdout0_22ck109 = 0 time = 550
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=550.025n

* CHECK dout0_23 Vdout0_23ck109 = 0 time = 550
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=550.025n

* CHECK dout0_24 Vdout0_24ck109 = 0 time = 550
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=550.025n

* CHECK dout0_25 Vdout0_25ck109 = 1.1 time = 550
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=550.025n

* CHECK dout0_26 Vdout0_26ck109 = 0 time = 550
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=550.025n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 550
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=550.025n

* CHECK dout0_28 Vdout0_28ck109 = 1.1 time = 550
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=550.025n

* CHECK dout0_29 Vdout0_29ck109 = 0 time = 550
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=550.025n

* CHECK dout0_30 Vdout0_30ck109 = 0 time = 550
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=550.025n

* CHECK dout0_31 Vdout0_31ck109 = 0 time = 550
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=550.025n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 560
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=560.025n

* CHECK dout0_1 Vdout0_1ck111 = 1.1 time = 560
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=560.025n

* CHECK dout0_2 Vdout0_2ck111 = 1.1 time = 560
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=560.025n

* CHECK dout0_3 Vdout0_3ck111 = 1.1 time = 560
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=560.025n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 560
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=560.025n

* CHECK dout0_5 Vdout0_5ck111 = 0 time = 560
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=560.025n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 560
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=560.025n

* CHECK dout0_7 Vdout0_7ck111 = 1.1 time = 560
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=560.025n

* CHECK dout0_8 Vdout0_8ck111 = 1.1 time = 560
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=560.025n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 560
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=560.025n

* CHECK dout0_10 Vdout0_10ck111 = 1.1 time = 560
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=560.025n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 560
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=560.025n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 560
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=560.025n

* CHECK dout0_13 Vdout0_13ck111 = 1.1 time = 560
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=560.025n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 560
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=560.025n

* CHECK dout0_15 Vdout0_15ck111 = 1.1 time = 560
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=560.025n

* CHECK dout0_16 Vdout0_16ck111 = 0 time = 560
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=560.025n

* CHECK dout0_17 Vdout0_17ck111 = 1.1 time = 560
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=560.025n

* CHECK dout0_18 Vdout0_18ck111 = 0 time = 560
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=560.025n

* CHECK dout0_19 Vdout0_19ck111 = 0 time = 560
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=560.025n

* CHECK dout0_20 Vdout0_20ck111 = 0 time = 560
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=560.025n

* CHECK dout0_21 Vdout0_21ck111 = 0 time = 560
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=560.025n

* CHECK dout0_22 Vdout0_22ck111 = 1.1 time = 560
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=560.025n

* CHECK dout0_23 Vdout0_23ck111 = 0 time = 560
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=560.025n

* CHECK dout0_24 Vdout0_24ck111 = 0 time = 560
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=560.025n

* CHECK dout0_25 Vdout0_25ck111 = 0 time = 560
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=560.025n

* CHECK dout0_26 Vdout0_26ck111 = 1.1 time = 560
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=560.025n

* CHECK dout0_27 Vdout0_27ck111 = 0 time = 560
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=560.025n

* CHECK dout0_28 Vdout0_28ck111 = 0 time = 560
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=560.025n

* CHECK dout0_29 Vdout0_29ck111 = 1.1 time = 560
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=560.025n

* CHECK dout0_30 Vdout0_30ck111 = 0 time = 560
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=560.025n

* CHECK dout0_31 Vdout0_31ck111 = 0 time = 560
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=560.025n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 565
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=565.025n

* CHECK dout0_1 Vdout0_1ck112 = 1.1 time = 565
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=565.025n

* CHECK dout0_2 Vdout0_2ck112 = 0 time = 565
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=565.025n

* CHECK dout0_3 Vdout0_3ck112 = 1.1 time = 565
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=565.025n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 565
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=565.025n

* CHECK dout0_5 Vdout0_5ck112 = 1.1 time = 565
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=565.025n

* CHECK dout0_6 Vdout0_6ck112 = 1.1 time = 565
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=565.025n

* CHECK dout0_7 Vdout0_7ck112 = 1.1 time = 565
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=565.025n

* CHECK dout0_8 Vdout0_8ck112 = 1.1 time = 565
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=565.025n

* CHECK dout0_9 Vdout0_9ck112 = 1.1 time = 565
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=565.025n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 565
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=565.025n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 565
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=565.025n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 565
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=565.025n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 565
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=565.025n

* CHECK dout0_14 Vdout0_14ck112 = 1.1 time = 565
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=565.025n

* CHECK dout0_15 Vdout0_15ck112 = 1.1 time = 565
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=565.025n

* CHECK dout0_16 Vdout0_16ck112 = 0 time = 565
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=565.025n

* CHECK dout0_17 Vdout0_17ck112 = 0 time = 565
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=565.025n

* CHECK dout0_18 Vdout0_18ck112 = 0 time = 565
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=565.025n

* CHECK dout0_19 Vdout0_19ck112 = 0 time = 565
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=565.025n

* CHECK dout0_20 Vdout0_20ck112 = 0 time = 565
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=565.025n

* CHECK dout0_21 Vdout0_21ck112 = 1.1 time = 565
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=565.025n

* CHECK dout0_22 Vdout0_22ck112 = 1.1 time = 565
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=565.025n

* CHECK dout0_23 Vdout0_23ck112 = 1.1 time = 565
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=565.025n

* CHECK dout0_24 Vdout0_24ck112 = 1.1 time = 565
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=565.025n

* CHECK dout0_25 Vdout0_25ck112 = 0 time = 565
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=565.025n

* CHECK dout0_26 Vdout0_26ck112 = 0 time = 565
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=565.025n

* CHECK dout0_27 Vdout0_27ck112 = 0 time = 565
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=565.025n

* CHECK dout0_28 Vdout0_28ck112 = 1.1 time = 565
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=565.025n

* CHECK dout0_29 Vdout0_29ck112 = 0 time = 565
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=565.025n

* CHECK dout0_30 Vdout0_30ck112 = 1.1 time = 565
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=565.025n

* CHECK dout0_31 Vdout0_31ck112 = 1.1 time = 565
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=565.025n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 1.1 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 1.1 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 1.1 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 1.1 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 1.1 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 0 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 1.1 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 1.1 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 0 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 1.1 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 1.1 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 0 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 1.1 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 1.1 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 0 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 1.1 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 0 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 0 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_0 Vdout0_0ck114 = 1.1 time = 575
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=575.025n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 575
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=575.025n

* CHECK dout0_2 Vdout0_2ck114 = 0 time = 575
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=575.025n

* CHECK dout0_3 Vdout0_3ck114 = 0 time = 575
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=575.025n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 575
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=575.025n

* CHECK dout0_5 Vdout0_5ck114 = 1.1 time = 575
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=575.025n

* CHECK dout0_6 Vdout0_6ck114 = 1.1 time = 575
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=575.025n

* CHECK dout0_7 Vdout0_7ck114 = 0 time = 575
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=575.025n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 575
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=575.025n

* CHECK dout0_9 Vdout0_9ck114 = 0 time = 575
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=575.025n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 575
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=575.025n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 575
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=575.025n

* CHECK dout0_12 Vdout0_12ck114 = 1.1 time = 575
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=575.025n

* CHECK dout0_13 Vdout0_13ck114 = 1.1 time = 575
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=575.025n

* CHECK dout0_14 Vdout0_14ck114 = 0 time = 575
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=575.025n

* CHECK dout0_15 Vdout0_15ck114 = 1.1 time = 575
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=575.025n

* CHECK dout0_16 Vdout0_16ck114 = 0 time = 575
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=575.025n

* CHECK dout0_17 Vdout0_17ck114 = 0 time = 575
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=575.025n

* CHECK dout0_18 Vdout0_18ck114 = 1.1 time = 575
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=575.025n

* CHECK dout0_19 Vdout0_19ck114 = 0 time = 575
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=575.025n

* CHECK dout0_20 Vdout0_20ck114 = 0 time = 575
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=575.025n

* CHECK dout0_21 Vdout0_21ck114 = 0 time = 575
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=575.025n

* CHECK dout0_22 Vdout0_22ck114 = 1.1 time = 575
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=575.025n

* CHECK dout0_23 Vdout0_23ck114 = 1.1 time = 575
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=575.025n

* CHECK dout0_24 Vdout0_24ck114 = 1.1 time = 575
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=575.025n

* CHECK dout0_25 Vdout0_25ck114 = 1.1 time = 575
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=575.025n

* CHECK dout0_26 Vdout0_26ck114 = 0 time = 575
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=575.025n

* CHECK dout0_27 Vdout0_27ck114 = 1.1 time = 575
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=575.025n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 575
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=575.025n

* CHECK dout0_29 Vdout0_29ck114 = 0 time = 575
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=575.025n

* CHECK dout0_30 Vdout0_30ck114 = 0 time = 575
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=575.025n

* CHECK dout0_31 Vdout0_31ck114 = 0 time = 575
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=575.025n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 585
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=585.025n

* CHECK dout0_1 Vdout0_1ck116 = 1.1 time = 585
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=585.025n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 585
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=585.025n

* CHECK dout0_3 Vdout0_3ck116 = 1.1 time = 585
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=585.025n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 585
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=585.025n

* CHECK dout0_5 Vdout0_5ck116 = 1.1 time = 585
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=585.025n

* CHECK dout0_6 Vdout0_6ck116 = 1.1 time = 585
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=585.025n

* CHECK dout0_7 Vdout0_7ck116 = 1.1 time = 585
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=585.025n

* CHECK dout0_8 Vdout0_8ck116 = 1.1 time = 585
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=585.025n

* CHECK dout0_9 Vdout0_9ck116 = 1.1 time = 585
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=585.025n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 585
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=585.025n

* CHECK dout0_11 Vdout0_11ck116 = 0 time = 585
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=585.025n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 585
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=585.025n

* CHECK dout0_13 Vdout0_13ck116 = 0 time = 585
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=585.025n

* CHECK dout0_14 Vdout0_14ck116 = 1.1 time = 585
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=585.025n

* CHECK dout0_15 Vdout0_15ck116 = 1.1 time = 585
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=585.025n

* CHECK dout0_16 Vdout0_16ck116 = 0 time = 585
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=585.025n

* CHECK dout0_17 Vdout0_17ck116 = 0 time = 585
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=585.025n

* CHECK dout0_18 Vdout0_18ck116 = 0 time = 585
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=585.025n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 585
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=585.025n

* CHECK dout0_20 Vdout0_20ck116 = 0 time = 585
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=585.025n

* CHECK dout0_21 Vdout0_21ck116 = 1.1 time = 585
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=585.025n

* CHECK dout0_22 Vdout0_22ck116 = 1.1 time = 585
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=585.025n

* CHECK dout0_23 Vdout0_23ck116 = 1.1 time = 585
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=585.025n

* CHECK dout0_24 Vdout0_24ck116 = 1.1 time = 585
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=585.025n

* CHECK dout0_25 Vdout0_25ck116 = 0 time = 585
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=585.025n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 585
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=585.025n

* CHECK dout0_27 Vdout0_27ck116 = 0 time = 585
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=585.025n

* CHECK dout0_28 Vdout0_28ck116 = 1.1 time = 585
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=585.025n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 585
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=585.025n

* CHECK dout0_30 Vdout0_30ck116 = 1.1 time = 585
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=585.025n

* CHECK dout0_31 Vdout0_31ck116 = 1.1 time = 585
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=585.025n

* CHECK dout0_0 Vdout0_0ck119 = 1.1 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 0 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 0 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 1.1 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 1.1 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 1.1 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 1.1 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 0 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 1.1 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 0 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 1.1 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 1.1 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 1.1 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 1.1 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 1.1 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 0 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 1.1 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 0 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_0 Vdout0_0ck120 = 1.1 time = 605
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=605.025n

* CHECK dout0_1 Vdout0_1ck120 = 1.1 time = 605
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=605.025n

* CHECK dout0_2 Vdout0_2ck120 = 1.1 time = 605
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=605.025n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 605
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=605.025n

* CHECK dout0_4 Vdout0_4ck120 = 1.1 time = 605
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=605.025n

* CHECK dout0_5 Vdout0_5ck120 = 1.1 time = 605
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=605.025n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 605
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=605.025n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 605
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=605.025n

* CHECK dout0_8 Vdout0_8ck120 = 1.1 time = 605
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=605.025n

* CHECK dout0_9 Vdout0_9ck120 = 1.1 time = 605
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=605.025n

* CHECK dout0_10 Vdout0_10ck120 = 1.1 time = 605
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=605.025n

* CHECK dout0_11 Vdout0_11ck120 = 1.1 time = 605
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=605.025n

* CHECK dout0_12 Vdout0_12ck120 = 1.1 time = 605
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=605.025n

* CHECK dout0_13 Vdout0_13ck120 = 1.1 time = 605
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=605.025n

* CHECK dout0_14 Vdout0_14ck120 = 1.1 time = 605
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=605.025n

* CHECK dout0_15 Vdout0_15ck120 = 0 time = 605
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=605.025n

* CHECK dout0_16 Vdout0_16ck120 = 0 time = 605
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=605.025n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 605
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=605.025n

* CHECK dout0_18 Vdout0_18ck120 = 1.1 time = 605
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=605.025n

* CHECK dout0_19 Vdout0_19ck120 = 0 time = 605
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=605.025n

* CHECK dout0_20 Vdout0_20ck120 = 0 time = 605
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=605.025n

* CHECK dout0_21 Vdout0_21ck120 = 0 time = 605
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=605.025n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 605
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=605.025n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 605
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=605.025n

* CHECK dout0_24 Vdout0_24ck120 = 1.1 time = 605
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=605.025n

* CHECK dout0_25 Vdout0_25ck120 = 0 time = 605
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=605.025n

* CHECK dout0_26 Vdout0_26ck120 = 1.1 time = 605
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=605.025n

* CHECK dout0_27 Vdout0_27ck120 = 1.1 time = 605
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=605.025n

* CHECK dout0_28 Vdout0_28ck120 = 0 time = 605
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=605.025n

* CHECK dout0_29 Vdout0_29ck120 = 1.1 time = 605
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=605.025n

* CHECK dout0_30 Vdout0_30ck120 = 0 time = 605
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=605.025n

* CHECK dout0_31 Vdout0_31ck120 = 1.1 time = 605
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=605.025n

* CHECK dout0_0 Vdout0_0ck121 = 1.1 time = 610
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=610.025n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 610
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=610.025n

* CHECK dout0_2 Vdout0_2ck121 = 0 time = 610
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=610.025n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 610
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=610.025n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 610
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=610.025n

* CHECK dout0_5 Vdout0_5ck121 = 1.1 time = 610
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=610.025n

* CHECK dout0_6 Vdout0_6ck121 = 1.1 time = 610
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=610.025n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 610
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=610.025n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 610
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=610.025n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 610
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=610.025n

* CHECK dout0_10 Vdout0_10ck121 = 0 time = 610
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=610.025n

* CHECK dout0_11 Vdout0_11ck121 = 0 time = 610
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=610.025n

* CHECK dout0_12 Vdout0_12ck121 = 1.1 time = 610
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=610.025n

* CHECK dout0_13 Vdout0_13ck121 = 1.1 time = 610
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=610.025n

* CHECK dout0_14 Vdout0_14ck121 = 0 time = 610
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=610.025n

* CHECK dout0_15 Vdout0_15ck121 = 1.1 time = 610
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=610.025n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 610
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=610.025n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 610
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=610.025n

* CHECK dout0_18 Vdout0_18ck121 = 1.1 time = 610
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=610.025n

* CHECK dout0_19 Vdout0_19ck121 = 0 time = 610
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=610.025n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 610
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=610.025n

* CHECK dout0_21 Vdout0_21ck121 = 0 time = 610
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=610.025n

* CHECK dout0_22 Vdout0_22ck121 = 1.1 time = 610
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=610.025n

* CHECK dout0_23 Vdout0_23ck121 = 1.1 time = 610
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=610.025n

* CHECK dout0_24 Vdout0_24ck121 = 1.1 time = 610
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=610.025n

* CHECK dout0_25 Vdout0_25ck121 = 1.1 time = 610
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=610.025n

* CHECK dout0_26 Vdout0_26ck121 = 0 time = 610
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=610.025n

* CHECK dout0_27 Vdout0_27ck121 = 1.1 time = 610
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=610.025n

* CHECK dout0_28 Vdout0_28ck121 = 0 time = 610
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=610.025n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 610
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=610.025n

* CHECK dout0_30 Vdout0_30ck121 = 0 time = 610
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=610.025n

* CHECK dout0_31 Vdout0_31ck121 = 0 time = 610
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=610.025n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 615
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=615.025n

* CHECK dout0_1 Vdout0_1ck122 = 1.1 time = 615
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=615.025n

* CHECK dout0_2 Vdout0_2ck122 = 1.1 time = 615
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=615.025n

* CHECK dout0_3 Vdout0_3ck122 = 1.1 time = 615
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=615.025n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 615
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=615.025n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 615
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=615.025n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 615
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=615.025n

* CHECK dout0_7 Vdout0_7ck122 = 1.1 time = 615
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=615.025n

* CHECK dout0_8 Vdout0_8ck122 = 1.1 time = 615
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=615.025n

* CHECK dout0_9 Vdout0_9ck122 = 0 time = 615
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=615.025n

* CHECK dout0_10 Vdout0_10ck122 = 1.1 time = 615
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=615.025n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 615
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=615.025n

* CHECK dout0_12 Vdout0_12ck122 = 0 time = 615
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=615.025n

* CHECK dout0_13 Vdout0_13ck122 = 1.1 time = 615
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=615.025n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 615
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=615.025n

* CHECK dout0_15 Vdout0_15ck122 = 1.1 time = 615
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=615.025n

* CHECK dout0_16 Vdout0_16ck122 = 0 time = 615
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=615.025n

* CHECK dout0_17 Vdout0_17ck122 = 1.1 time = 615
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=615.025n

* CHECK dout0_18 Vdout0_18ck122 = 0 time = 615
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=615.025n

* CHECK dout0_19 Vdout0_19ck122 = 0 time = 615
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=615.025n

* CHECK dout0_20 Vdout0_20ck122 = 0 time = 615
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=615.025n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 615
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=615.025n

* CHECK dout0_22 Vdout0_22ck122 = 1.1 time = 615
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=615.025n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 615
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=615.025n

* CHECK dout0_24 Vdout0_24ck122 = 0 time = 615
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=615.025n

* CHECK dout0_25 Vdout0_25ck122 = 0 time = 615
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=615.025n

* CHECK dout0_26 Vdout0_26ck122 = 1.1 time = 615
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=615.025n

* CHECK dout0_27 Vdout0_27ck122 = 0 time = 615
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=615.025n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 615
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=615.025n

* CHECK dout0_29 Vdout0_29ck122 = 1.1 time = 615
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=615.025n

* CHECK dout0_30 Vdout0_30ck122 = 0 time = 615
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=615.025n

* CHECK dout0_31 Vdout0_31ck122 = 0 time = 615
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=615.025n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 1.1 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 1.1 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 1.1 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 1.1 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 1.1 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 0 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 1.1 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 1.1 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 1.1 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 0 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 1.1 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 0 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 1.1 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 1.1 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 0 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 0 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 1.1 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 0 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 625
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=625.025n

* CHECK dout0_1 Vdout0_1ck124 = 1.1 time = 625
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=625.025n

* CHECK dout0_2 Vdout0_2ck124 = 1.1 time = 625
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=625.025n

* CHECK dout0_3 Vdout0_3ck124 = 0 time = 625
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=625.025n

* CHECK dout0_4 Vdout0_4ck124 = 1.1 time = 625
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=625.025n

* CHECK dout0_5 Vdout0_5ck124 = 1.1 time = 625
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=625.025n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 625
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=625.025n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 625
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=625.025n

* CHECK dout0_8 Vdout0_8ck124 = 0 time = 625
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=625.025n

* CHECK dout0_9 Vdout0_9ck124 = 0 time = 625
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=625.025n

* CHECK dout0_10 Vdout0_10ck124 = 1.1 time = 625
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=625.025n

* CHECK dout0_11 Vdout0_11ck124 = 0 time = 625
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=625.025n

* CHECK dout0_12 Vdout0_12ck124 = 1.1 time = 625
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=625.025n

* CHECK dout0_13 Vdout0_13ck124 = 1.1 time = 625
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=625.025n

* CHECK dout0_14 Vdout0_14ck124 = 0 time = 625
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=625.025n

* CHECK dout0_15 Vdout0_15ck124 = 0 time = 625
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=625.025n

* CHECK dout0_16 Vdout0_16ck124 = 0 time = 625
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=625.025n

* CHECK dout0_17 Vdout0_17ck124 = 1.1 time = 625
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=625.025n

* CHECK dout0_18 Vdout0_18ck124 = 0 time = 625
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=625.025n

* CHECK dout0_19 Vdout0_19ck124 = 0 time = 625
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=625.025n

* CHECK dout0_20 Vdout0_20ck124 = 1.1 time = 625
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=625.025n

* CHECK dout0_21 Vdout0_21ck124 = 1.1 time = 625
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=625.025n

* CHECK dout0_22 Vdout0_22ck124 = 1.1 time = 625
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=625.025n

* CHECK dout0_23 Vdout0_23ck124 = 1.1 time = 625
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=625.025n

* CHECK dout0_24 Vdout0_24ck124 = 1.1 time = 625
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=625.025n

* CHECK dout0_25 Vdout0_25ck124 = 0 time = 625
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=625.025n

* CHECK dout0_26 Vdout0_26ck124 = 0 time = 625
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=625.025n

* CHECK dout0_27 Vdout0_27ck124 = 0 time = 625
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=625.025n

* CHECK dout0_28 Vdout0_28ck124 = 1.1 time = 625
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=625.025n

* CHECK dout0_29 Vdout0_29ck124 = 0 time = 625
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=625.025n

* CHECK dout0_30 Vdout0_30ck124 = 1.1 time = 625
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=625.025n

* CHECK dout0_31 Vdout0_31ck124 = 1.1 time = 625
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=625.025n

* CHECK dout0_0 Vdout0_0ck125 = 1.1 time = 630
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=630.025n

* CHECK dout0_1 Vdout0_1ck125 = 0 time = 630
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=630.025n

* CHECK dout0_2 Vdout0_2ck125 = 1.1 time = 630
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=630.025n

* CHECK dout0_3 Vdout0_3ck125 = 1.1 time = 630
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=630.025n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 630
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=630.025n

* CHECK dout0_5 Vdout0_5ck125 = 0 time = 630
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=630.025n

* CHECK dout0_6 Vdout0_6ck125 = 1.1 time = 630
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=630.025n

* CHECK dout0_7 Vdout0_7ck125 = 0 time = 630
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=630.025n

* CHECK dout0_8 Vdout0_8ck125 = 1.1 time = 630
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=630.025n

* CHECK dout0_9 Vdout0_9ck125 = 1.1 time = 630
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=630.025n

* CHECK dout0_10 Vdout0_10ck125 = 0 time = 630
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=630.025n

* CHECK dout0_11 Vdout0_11ck125 = 0 time = 630
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=630.025n

* CHECK dout0_12 Vdout0_12ck125 = 1.1 time = 630
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=630.025n

* CHECK dout0_13 Vdout0_13ck125 = 1.1 time = 630
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=630.025n

* CHECK dout0_14 Vdout0_14ck125 = 1.1 time = 630
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=630.025n

* CHECK dout0_15 Vdout0_15ck125 = 0 time = 630
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=630.025n

* CHECK dout0_16 Vdout0_16ck125 = 0 time = 630
.meas tran vdout0_16ck125 FIND v(dout0_16) AT=630.025n

* CHECK dout0_17 Vdout0_17ck125 = 0 time = 630
.meas tran vdout0_17ck125 FIND v(dout0_17) AT=630.025n

* CHECK dout0_18 Vdout0_18ck125 = 0 time = 630
.meas tran vdout0_18ck125 FIND v(dout0_18) AT=630.025n

* CHECK dout0_19 Vdout0_19ck125 = 0 time = 630
.meas tran vdout0_19ck125 FIND v(dout0_19) AT=630.025n

* CHECK dout0_20 Vdout0_20ck125 = 1.1 time = 630
.meas tran vdout0_20ck125 FIND v(dout0_20) AT=630.025n

* CHECK dout0_21 Vdout0_21ck125 = 1.1 time = 630
.meas tran vdout0_21ck125 FIND v(dout0_21) AT=630.025n

* CHECK dout0_22 Vdout0_22ck125 = 0 time = 630
.meas tran vdout0_22ck125 FIND v(dout0_22) AT=630.025n

* CHECK dout0_23 Vdout0_23ck125 = 1.1 time = 630
.meas tran vdout0_23ck125 FIND v(dout0_23) AT=630.025n

* CHECK dout0_24 Vdout0_24ck125 = 0 time = 630
.meas tran vdout0_24ck125 FIND v(dout0_24) AT=630.025n

* CHECK dout0_25 Vdout0_25ck125 = 1.1 time = 630
.meas tran vdout0_25ck125 FIND v(dout0_25) AT=630.025n

* CHECK dout0_26 Vdout0_26ck125 = 0 time = 630
.meas tran vdout0_26ck125 FIND v(dout0_26) AT=630.025n

* CHECK dout0_27 Vdout0_27ck125 = 1.1 time = 630
.meas tran vdout0_27ck125 FIND v(dout0_27) AT=630.025n

* CHECK dout0_28 Vdout0_28ck125 = 1.1 time = 630
.meas tran vdout0_28ck125 FIND v(dout0_28) AT=630.025n

* CHECK dout0_29 Vdout0_29ck125 = 1.1 time = 630
.meas tran vdout0_29ck125 FIND v(dout0_29) AT=630.025n

* CHECK dout0_30 Vdout0_30ck125 = 0 time = 630
.meas tran vdout0_30ck125 FIND v(dout0_30) AT=630.025n

* CHECK dout0_31 Vdout0_31ck125 = 0 time = 630
.meas tran vdout0_31ck125 FIND v(dout0_31) AT=630.025n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 635
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=635.025n

* CHECK dout0_1 Vdout0_1ck126 = 1.1 time = 635
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=635.025n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 635
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=635.025n

* CHECK dout0_3 Vdout0_3ck126 = 1.1 time = 635
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=635.025n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 635
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=635.025n

* CHECK dout0_5 Vdout0_5ck126 = 1.1 time = 635
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=635.025n

* CHECK dout0_6 Vdout0_6ck126 = 1.1 time = 635
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=635.025n

* CHECK dout0_7 Vdout0_7ck126 = 1.1 time = 635
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=635.025n

* CHECK dout0_8 Vdout0_8ck126 = 1.1 time = 635
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=635.025n

* CHECK dout0_9 Vdout0_9ck126 = 1.1 time = 635
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=635.025n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 635
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=635.025n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 635
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=635.025n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 635
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=635.025n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 635
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=635.025n

* CHECK dout0_14 Vdout0_14ck126 = 1.1 time = 635
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=635.025n

* CHECK dout0_15 Vdout0_15ck126 = 1.1 time = 635
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=635.025n

* CHECK dout0_16 Vdout0_16ck126 = 0 time = 635
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=635.025n

* CHECK dout0_17 Vdout0_17ck126 = 0 time = 635
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=635.025n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 635
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=635.025n

* CHECK dout0_19 Vdout0_19ck126 = 0 time = 635
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=635.025n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 635
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=635.025n

* CHECK dout0_21 Vdout0_21ck126 = 1.1 time = 635
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=635.025n

* CHECK dout0_22 Vdout0_22ck126 = 1.1 time = 635
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=635.025n

* CHECK dout0_23 Vdout0_23ck126 = 1.1 time = 635
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=635.025n

* CHECK dout0_24 Vdout0_24ck126 = 1.1 time = 635
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=635.025n

* CHECK dout0_25 Vdout0_25ck126 = 0 time = 635
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=635.025n

* CHECK dout0_26 Vdout0_26ck126 = 0 time = 635
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=635.025n

* CHECK dout0_27 Vdout0_27ck126 = 0 time = 635
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=635.025n

* CHECK dout0_28 Vdout0_28ck126 = 1.1 time = 635
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=635.025n

* CHECK dout0_29 Vdout0_29ck126 = 0 time = 635
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=635.025n

* CHECK dout0_30 Vdout0_30ck126 = 1.1 time = 635
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=635.025n

* CHECK dout0_31 Vdout0_31ck126 = 1.1 time = 635
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=635.025n

* CHECK dout0_0 Vdout0_0ck128 = 1.1 time = 645
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=645.025n

* CHECK dout0_1 Vdout0_1ck128 = 0 time = 645
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=645.025n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 645
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=645.025n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 645
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=645.025n

* CHECK dout0_4 Vdout0_4ck128 = 0 time = 645
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=645.025n

* CHECK dout0_5 Vdout0_5ck128 = 1.1 time = 645
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=645.025n

* CHECK dout0_6 Vdout0_6ck128 = 1.1 time = 645
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=645.025n

* CHECK dout0_7 Vdout0_7ck128 = 0 time = 645
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=645.025n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 645
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=645.025n

* CHECK dout0_9 Vdout0_9ck128 = 0 time = 645
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=645.025n

* CHECK dout0_10 Vdout0_10ck128 = 0 time = 645
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=645.025n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 645
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=645.025n

* CHECK dout0_12 Vdout0_12ck128 = 1.1 time = 645
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=645.025n

* CHECK dout0_13 Vdout0_13ck128 = 1.1 time = 645
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=645.025n

* CHECK dout0_14 Vdout0_14ck128 = 0 time = 645
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=645.025n

* CHECK dout0_15 Vdout0_15ck128 = 1.1 time = 645
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=645.025n

* CHECK dout0_16 Vdout0_16ck128 = 0 time = 645
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=645.025n

* CHECK dout0_17 Vdout0_17ck128 = 0 time = 645
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=645.025n

* CHECK dout0_18 Vdout0_18ck128 = 1.1 time = 645
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=645.025n

* CHECK dout0_19 Vdout0_19ck128 = 0 time = 645
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=645.025n

* CHECK dout0_20 Vdout0_20ck128 = 0 time = 645
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=645.025n

* CHECK dout0_21 Vdout0_21ck128 = 0 time = 645
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=645.025n

* CHECK dout0_22 Vdout0_22ck128 = 1.1 time = 645
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=645.025n

* CHECK dout0_23 Vdout0_23ck128 = 1.1 time = 645
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=645.025n

* CHECK dout0_24 Vdout0_24ck128 = 1.1 time = 645
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=645.025n

* CHECK dout0_25 Vdout0_25ck128 = 1.1 time = 645
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=645.025n

* CHECK dout0_26 Vdout0_26ck128 = 0 time = 645
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=645.025n

* CHECK dout0_27 Vdout0_27ck128 = 1.1 time = 645
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=645.025n

* CHECK dout0_28 Vdout0_28ck128 = 0 time = 645
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=645.025n

* CHECK dout0_29 Vdout0_29ck128 = 0 time = 645
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=645.025n

* CHECK dout0_30 Vdout0_30ck128 = 0 time = 645
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=645.025n

* CHECK dout0_31 Vdout0_31ck128 = 0 time = 645
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=645.025n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 670
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=670.025n

* CHECK dout0_1 Vdout0_1ck133 = 0 time = 670
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=670.025n

* CHECK dout0_2 Vdout0_2ck133 = 1.1 time = 670
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=670.025n

* CHECK dout0_3 Vdout0_3ck133 = 1.1 time = 670
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=670.025n

* CHECK dout0_4 Vdout0_4ck133 = 1.1 time = 670
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=670.025n

* CHECK dout0_5 Vdout0_5ck133 = 1.1 time = 670
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=670.025n

* CHECK dout0_6 Vdout0_6ck133 = 0 time = 670
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=670.025n

* CHECK dout0_7 Vdout0_7ck133 = 0 time = 670
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=670.025n

* CHECK dout0_8 Vdout0_8ck133 = 1.1 time = 670
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=670.025n

* CHECK dout0_9 Vdout0_9ck133 = 0 time = 670
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=670.025n

* CHECK dout0_10 Vdout0_10ck133 = 1.1 time = 670
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=670.025n

* CHECK dout0_11 Vdout0_11ck133 = 1.1 time = 670
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=670.025n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 670
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=670.025n

* CHECK dout0_13 Vdout0_13ck133 = 1.1 time = 670
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=670.025n

* CHECK dout0_14 Vdout0_14ck133 = 0 time = 670
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=670.025n

* CHECK dout0_15 Vdout0_15ck133 = 0 time = 670
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=670.025n

* CHECK dout0_16 Vdout0_16ck133 = 0 time = 670
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=670.025n

* CHECK dout0_17 Vdout0_17ck133 = 1.1 time = 670
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=670.025n

* CHECK dout0_18 Vdout0_18ck133 = 0 time = 670
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=670.025n

* CHECK dout0_19 Vdout0_19ck133 = 1.1 time = 670
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=670.025n

* CHECK dout0_20 Vdout0_20ck133 = 1.1 time = 670
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=670.025n

* CHECK dout0_21 Vdout0_21ck133 = 0 time = 670
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=670.025n

* CHECK dout0_22 Vdout0_22ck133 = 1.1 time = 670
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=670.025n

* CHECK dout0_23 Vdout0_23ck133 = 1.1 time = 670
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=670.025n

* CHECK dout0_24 Vdout0_24ck133 = 0 time = 670
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=670.025n

* CHECK dout0_25 Vdout0_25ck133 = 1.1 time = 670
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=670.025n

* CHECK dout0_26 Vdout0_26ck133 = 0 time = 670
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=670.025n

* CHECK dout0_27 Vdout0_27ck133 = 0 time = 670
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=670.025n

* CHECK dout0_28 Vdout0_28ck133 = 1.1 time = 670
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=670.025n

* CHECK dout0_29 Vdout0_29ck133 = 1.1 time = 670
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=670.025n

* CHECK dout0_30 Vdout0_30ck133 = 0 time = 670
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=670.025n

* CHECK dout0_31 Vdout0_31ck133 = 0 time = 670
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=670.025n

* CHECK dout0_0 Vdout0_0ck137 = 1.1 time = 690
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=690.025n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 690
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=690.025n

* CHECK dout0_2 Vdout0_2ck137 = 1.1 time = 690
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=690.025n

* CHECK dout0_3 Vdout0_3ck137 = 1.1 time = 690
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=690.025n

* CHECK dout0_4 Vdout0_4ck137 = 0 time = 690
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=690.025n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 690
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=690.025n

* CHECK dout0_6 Vdout0_6ck137 = 1.1 time = 690
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=690.025n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 690
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=690.025n

* CHECK dout0_8 Vdout0_8ck137 = 1.1 time = 690
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=690.025n

* CHECK dout0_9 Vdout0_9ck137 = 1.1 time = 690
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=690.025n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 690
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=690.025n

* CHECK dout0_11 Vdout0_11ck137 = 0 time = 690
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=690.025n

* CHECK dout0_12 Vdout0_12ck137 = 1.1 time = 690
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=690.025n

* CHECK dout0_13 Vdout0_13ck137 = 1.1 time = 690
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=690.025n

* CHECK dout0_14 Vdout0_14ck137 = 1.1 time = 690
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=690.025n

* CHECK dout0_15 Vdout0_15ck137 = 0 time = 690
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=690.025n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 690
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=690.025n

* CHECK dout0_17 Vdout0_17ck137 = 0 time = 690
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=690.025n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 690
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=690.025n

* CHECK dout0_19 Vdout0_19ck137 = 0 time = 690
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=690.025n

* CHECK dout0_20 Vdout0_20ck137 = 1.1 time = 690
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=690.025n

* CHECK dout0_21 Vdout0_21ck137 = 1.1 time = 690
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=690.025n

* CHECK dout0_22 Vdout0_22ck137 = 0 time = 690
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=690.025n

* CHECK dout0_23 Vdout0_23ck137 = 1.1 time = 690
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=690.025n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 690
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=690.025n

* CHECK dout0_25 Vdout0_25ck137 = 1.1 time = 690
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=690.025n

* CHECK dout0_26 Vdout0_26ck137 = 0 time = 690
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=690.025n

* CHECK dout0_27 Vdout0_27ck137 = 1.1 time = 690
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=690.025n

* CHECK dout0_28 Vdout0_28ck137 = 1.1 time = 690
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=690.025n

* CHECK dout0_29 Vdout0_29ck137 = 1.1 time = 690
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=690.025n

* CHECK dout0_30 Vdout0_30ck137 = 0 time = 690
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=690.025n

* CHECK dout0_31 Vdout0_31ck137 = 0 time = 690
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=690.025n

* CHECK dout0_0 Vdout0_0ck139 = 1.1 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 1.1 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 1.1 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 0 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 0 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 1.1 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 1.1 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 0 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 1.1 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 0 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 1.1 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 1.1 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 1.1 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 1.1 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 1.1 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 1.1 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 705
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=705.025n

* CHECK dout0_1 Vdout0_1ck140 = 1.1 time = 705
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=705.025n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 705
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=705.025n

* CHECK dout0_3 Vdout0_3ck140 = 1.1 time = 705
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=705.025n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 705
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=705.025n

* CHECK dout0_5 Vdout0_5ck140 = 1.1 time = 705
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=705.025n

* CHECK dout0_6 Vdout0_6ck140 = 1.1 time = 705
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=705.025n

* CHECK dout0_7 Vdout0_7ck140 = 1.1 time = 705
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=705.025n

* CHECK dout0_8 Vdout0_8ck140 = 1.1 time = 705
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=705.025n

* CHECK dout0_9 Vdout0_9ck140 = 1.1 time = 705
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=705.025n

* CHECK dout0_10 Vdout0_10ck140 = 0 time = 705
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=705.025n

* CHECK dout0_11 Vdout0_11ck140 = 0 time = 705
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=705.025n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 705
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=705.025n

* CHECK dout0_13 Vdout0_13ck140 = 0 time = 705
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=705.025n

* CHECK dout0_14 Vdout0_14ck140 = 1.1 time = 705
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=705.025n

* CHECK dout0_15 Vdout0_15ck140 = 1.1 time = 705
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=705.025n

* CHECK dout0_16 Vdout0_16ck140 = 0 time = 705
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=705.025n

* CHECK dout0_17 Vdout0_17ck140 = 0 time = 705
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=705.025n

* CHECK dout0_18 Vdout0_18ck140 = 0 time = 705
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=705.025n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 705
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=705.025n

* CHECK dout0_20 Vdout0_20ck140 = 0 time = 705
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=705.025n

* CHECK dout0_21 Vdout0_21ck140 = 1.1 time = 705
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=705.025n

* CHECK dout0_22 Vdout0_22ck140 = 1.1 time = 705
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=705.025n

* CHECK dout0_23 Vdout0_23ck140 = 1.1 time = 705
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=705.025n

* CHECK dout0_24 Vdout0_24ck140 = 1.1 time = 705
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=705.025n

* CHECK dout0_25 Vdout0_25ck140 = 0 time = 705
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=705.025n

* CHECK dout0_26 Vdout0_26ck140 = 0 time = 705
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=705.025n

* CHECK dout0_27 Vdout0_27ck140 = 0 time = 705
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=705.025n

* CHECK dout0_28 Vdout0_28ck140 = 1.1 time = 705
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=705.025n

* CHECK dout0_29 Vdout0_29ck140 = 0 time = 705
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=705.025n

* CHECK dout0_30 Vdout0_30ck140 = 1.1 time = 705
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=705.025n

* CHECK dout0_31 Vdout0_31ck140 = 1.1 time = 705
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=705.025n

* CHECK dout0_0 Vdout0_0ck141 = 1.1 time = 710
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=710.025n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 710
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=710.025n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 710
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=710.025n

* CHECK dout0_3 Vdout0_3ck141 = 0 time = 710
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=710.025n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 710
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=710.025n

* CHECK dout0_5 Vdout0_5ck141 = 1.1 time = 710
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=710.025n

* CHECK dout0_6 Vdout0_6ck141 = 1.1 time = 710
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=710.025n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 710
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=710.025n

* CHECK dout0_8 Vdout0_8ck141 = 0 time = 710
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=710.025n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 710
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=710.025n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 710
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=710.025n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 710
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=710.025n

* CHECK dout0_12 Vdout0_12ck141 = 1.1 time = 710
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=710.025n

* CHECK dout0_13 Vdout0_13ck141 = 1.1 time = 710
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=710.025n

* CHECK dout0_14 Vdout0_14ck141 = 0 time = 710
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=710.025n

* CHECK dout0_15 Vdout0_15ck141 = 1.1 time = 710
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=710.025n

* CHECK dout0_16 Vdout0_16ck141 = 0 time = 710
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=710.025n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 710
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=710.025n

* CHECK dout0_18 Vdout0_18ck141 = 1.1 time = 710
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=710.025n

* CHECK dout0_19 Vdout0_19ck141 = 0 time = 710
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=710.025n

* CHECK dout0_20 Vdout0_20ck141 = 0 time = 710
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=710.025n

* CHECK dout0_21 Vdout0_21ck141 = 0 time = 710
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=710.025n

* CHECK dout0_22 Vdout0_22ck141 = 1.1 time = 710
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=710.025n

* CHECK dout0_23 Vdout0_23ck141 = 1.1 time = 710
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=710.025n

* CHECK dout0_24 Vdout0_24ck141 = 1.1 time = 710
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=710.025n

* CHECK dout0_25 Vdout0_25ck141 = 1.1 time = 710
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=710.025n

* CHECK dout0_26 Vdout0_26ck141 = 0 time = 710
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=710.025n

* CHECK dout0_27 Vdout0_27ck141 = 1.1 time = 710
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=710.025n

* CHECK dout0_28 Vdout0_28ck141 = 0 time = 710
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=710.025n

* CHECK dout0_29 Vdout0_29ck141 = 0 time = 710
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=710.025n

* CHECK dout0_30 Vdout0_30ck141 = 0 time = 710
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=710.025n

* CHECK dout0_31 Vdout0_31ck141 = 0 time = 710
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=710.025n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 745
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=745.025n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 745
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=745.025n

* CHECK dout0_2 Vdout0_2ck148 = 1.1 time = 745
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=745.025n

* CHECK dout0_3 Vdout0_3ck148 = 1.1 time = 745
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=745.025n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 745
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=745.025n

* CHECK dout0_5 Vdout0_5ck148 = 1.1 time = 745
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=745.025n

* CHECK dout0_6 Vdout0_6ck148 = 1.1 time = 745
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=745.025n

* CHECK dout0_7 Vdout0_7ck148 = 1.1 time = 745
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=745.025n

* CHECK dout0_8 Vdout0_8ck148 = 1.1 time = 745
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=745.025n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 745
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=745.025n

* CHECK dout0_10 Vdout0_10ck148 = 1.1 time = 745
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=745.025n

* CHECK dout0_11 Vdout0_11ck148 = 0 time = 745
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=745.025n

* CHECK dout0_12 Vdout0_12ck148 = 1.1 time = 745
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=745.025n

* CHECK dout0_13 Vdout0_13ck148 = 1.1 time = 745
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=745.025n

* CHECK dout0_14 Vdout0_14ck148 = 0 time = 745
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=745.025n

* CHECK dout0_15 Vdout0_15ck148 = 1.1 time = 745
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=745.025n

* CHECK dout0_16 Vdout0_16ck148 = 1.1 time = 745
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=745.025n

* CHECK dout0_17 Vdout0_17ck148 = 1.1 time = 745
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=745.025n

* CHECK dout0_18 Vdout0_18ck148 = 1.1 time = 745
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=745.025n

* CHECK dout0_19 Vdout0_19ck148 = 0 time = 745
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=745.025n

* CHECK dout0_20 Vdout0_20ck148 = 0 time = 745
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=745.025n

* CHECK dout0_21 Vdout0_21ck148 = 0 time = 745
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=745.025n

* CHECK dout0_22 Vdout0_22ck148 = 0 time = 745
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=745.025n

* CHECK dout0_23 Vdout0_23ck148 = 1.1 time = 745
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=745.025n

* CHECK dout0_24 Vdout0_24ck148 = 0 time = 745
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=745.025n

* CHECK dout0_25 Vdout0_25ck148 = 0 time = 745
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=745.025n

* CHECK dout0_26 Vdout0_26ck148 = 0 time = 745
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=745.025n

* CHECK dout0_27 Vdout0_27ck148 = 1.1 time = 745
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=745.025n

* CHECK dout0_28 Vdout0_28ck148 = 1.1 time = 745
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=745.025n

* CHECK dout0_29 Vdout0_29ck148 = 1.1 time = 745
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=745.025n

* CHECK dout0_30 Vdout0_30ck148 = 0 time = 745
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=745.025n

* CHECK dout0_31 Vdout0_31ck148 = 1.1 time = 745
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=745.025n

* CHECK dout0_0 Vdout0_0ck149 = 1.1 time = 750
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=750.025n

* CHECK dout0_1 Vdout0_1ck149 = 0 time = 750
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=750.025n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 750
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=750.025n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 750
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=750.025n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 750
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=750.025n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 750
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=750.025n

* CHECK dout0_6 Vdout0_6ck149 = 1.1 time = 750
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=750.025n

* CHECK dout0_7 Vdout0_7ck149 = 1.1 time = 750
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=750.025n

* CHECK dout0_8 Vdout0_8ck149 = 0 time = 750
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=750.025n

* CHECK dout0_9 Vdout0_9ck149 = 1.1 time = 750
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=750.025n

* CHECK dout0_10 Vdout0_10ck149 = 0 time = 750
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=750.025n

* CHECK dout0_11 Vdout0_11ck149 = 1.1 time = 750
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=750.025n

* CHECK dout0_12 Vdout0_12ck149 = 0 time = 750
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=750.025n

* CHECK dout0_13 Vdout0_13ck149 = 0 time = 750
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=750.025n

* CHECK dout0_14 Vdout0_14ck149 = 1.1 time = 750
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=750.025n

* CHECK dout0_15 Vdout0_15ck149 = 0 time = 750
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=750.025n

* CHECK dout0_16 Vdout0_16ck149 = 1.1 time = 750
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=750.025n

* CHECK dout0_17 Vdout0_17ck149 = 1.1 time = 750
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=750.025n

* CHECK dout0_18 Vdout0_18ck149 = 1.1 time = 750
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=750.025n

* CHECK dout0_19 Vdout0_19ck149 = 1.1 time = 750
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=750.025n

* CHECK dout0_20 Vdout0_20ck149 = 1.1 time = 750
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=750.025n

* CHECK dout0_21 Vdout0_21ck149 = 1.1 time = 750
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=750.025n

* CHECK dout0_22 Vdout0_22ck149 = 1.1 time = 750
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=750.025n

* CHECK dout0_23 Vdout0_23ck149 = 0 time = 750
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=750.025n

* CHECK dout0_24 Vdout0_24ck149 = 1.1 time = 750
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=750.025n

* CHECK dout0_25 Vdout0_25ck149 = 0 time = 750
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=750.025n

* CHECK dout0_26 Vdout0_26ck149 = 1.1 time = 750
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=750.025n

* CHECK dout0_27 Vdout0_27ck149 = 1.1 time = 750
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=750.025n

* CHECK dout0_28 Vdout0_28ck149 = 0 time = 750
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=750.025n

* CHECK dout0_29 Vdout0_29ck149 = 0 time = 750
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=750.025n

* CHECK dout0_30 Vdout0_30ck149 = 0 time = 750
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=750.025n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 750
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=750.025n

* CHECK dout0_0 Vdout0_0ck153 = 0 time = 770
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=770.025n

* CHECK dout0_1 Vdout0_1ck153 = 1.1 time = 770
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=770.025n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 770
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=770.025n

* CHECK dout0_3 Vdout0_3ck153 = 1.1 time = 770
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=770.025n

* CHECK dout0_4 Vdout0_4ck153 = 1.1 time = 770
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=770.025n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 770
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=770.025n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 770
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=770.025n

* CHECK dout0_7 Vdout0_7ck153 = 1.1 time = 770
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=770.025n

* CHECK dout0_8 Vdout0_8ck153 = 0 time = 770
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=770.025n

* CHECK dout0_9 Vdout0_9ck153 = 1.1 time = 770
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=770.025n

* CHECK dout0_10 Vdout0_10ck153 = 0 time = 770
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=770.025n

* CHECK dout0_11 Vdout0_11ck153 = 1.1 time = 770
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=770.025n

* CHECK dout0_12 Vdout0_12ck153 = 0 time = 770
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=770.025n

* CHECK dout0_13 Vdout0_13ck153 = 1.1 time = 770
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=770.025n

* CHECK dout0_14 Vdout0_14ck153 = 0 time = 770
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=770.025n

* CHECK dout0_15 Vdout0_15ck153 = 0 time = 770
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=770.025n

* CHECK dout0_16 Vdout0_16ck153 = 1.1 time = 770
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=770.025n

* CHECK dout0_17 Vdout0_17ck153 = 1.1 time = 770
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=770.025n

* CHECK dout0_18 Vdout0_18ck153 = 1.1 time = 770
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=770.025n

* CHECK dout0_19 Vdout0_19ck153 = 0 time = 770
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=770.025n

* CHECK dout0_20 Vdout0_20ck153 = 0 time = 770
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=770.025n

* CHECK dout0_21 Vdout0_21ck153 = 1.1 time = 770
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=770.025n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 770
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=770.025n

* CHECK dout0_23 Vdout0_23ck153 = 0 time = 770
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=770.025n

* CHECK dout0_24 Vdout0_24ck153 = 0 time = 770
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=770.025n

* CHECK dout0_25 Vdout0_25ck153 = 0 time = 770
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=770.025n

* CHECK dout0_26 Vdout0_26ck153 = 1.1 time = 770
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=770.025n

* CHECK dout0_27 Vdout0_27ck153 = 0 time = 770
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=770.025n

* CHECK dout0_28 Vdout0_28ck153 = 1.1 time = 770
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=770.025n

* CHECK dout0_29 Vdout0_29ck153 = 0 time = 770
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=770.025n

* CHECK dout0_30 Vdout0_30ck153 = 0 time = 770
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=770.025n

* CHECK dout0_31 Vdout0_31ck153 = 1.1 time = 770
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=770.025n

* CHECK dout0_0 Vdout0_0ck154 = 0 time = 775
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=775.025n

* CHECK dout0_1 Vdout0_1ck154 = 1.1 time = 775
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=775.025n

* CHECK dout0_2 Vdout0_2ck154 = 0 time = 775
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=775.025n

* CHECK dout0_3 Vdout0_3ck154 = 1.1 time = 775
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=775.025n

* CHECK dout0_4 Vdout0_4ck154 = 1.1 time = 775
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=775.025n

* CHECK dout0_5 Vdout0_5ck154 = 0 time = 775
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=775.025n

* CHECK dout0_6 Vdout0_6ck154 = 0 time = 775
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=775.025n

* CHECK dout0_7 Vdout0_7ck154 = 1.1 time = 775
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=775.025n

* CHECK dout0_8 Vdout0_8ck154 = 0 time = 775
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=775.025n

* CHECK dout0_9 Vdout0_9ck154 = 1.1 time = 775
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=775.025n

* CHECK dout0_10 Vdout0_10ck154 = 0 time = 775
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=775.025n

* CHECK dout0_11 Vdout0_11ck154 = 1.1 time = 775
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=775.025n

* CHECK dout0_12 Vdout0_12ck154 = 0 time = 775
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=775.025n

* CHECK dout0_13 Vdout0_13ck154 = 1.1 time = 775
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=775.025n

* CHECK dout0_14 Vdout0_14ck154 = 0 time = 775
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=775.025n

* CHECK dout0_15 Vdout0_15ck154 = 0 time = 775
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=775.025n

* CHECK dout0_16 Vdout0_16ck154 = 1.1 time = 775
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=775.025n

* CHECK dout0_17 Vdout0_17ck154 = 1.1 time = 775
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=775.025n

* CHECK dout0_18 Vdout0_18ck154 = 1.1 time = 775
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=775.025n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 775
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=775.025n

* CHECK dout0_20 Vdout0_20ck154 = 0 time = 775
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=775.025n

* CHECK dout0_21 Vdout0_21ck154 = 1.1 time = 775
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=775.025n

* CHECK dout0_22 Vdout0_22ck154 = 0 time = 775
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=775.025n

* CHECK dout0_23 Vdout0_23ck154 = 0 time = 775
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=775.025n

* CHECK dout0_24 Vdout0_24ck154 = 0 time = 775
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=775.025n

* CHECK dout0_25 Vdout0_25ck154 = 0 time = 775
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=775.025n

* CHECK dout0_26 Vdout0_26ck154 = 1.1 time = 775
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=775.025n

* CHECK dout0_27 Vdout0_27ck154 = 0 time = 775
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=775.025n

* CHECK dout0_28 Vdout0_28ck154 = 1.1 time = 775
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=775.025n

* CHECK dout0_29 Vdout0_29ck154 = 0 time = 775
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=775.025n

* CHECK dout0_30 Vdout0_30ck154 = 0 time = 775
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=775.025n

* CHECK dout0_31 Vdout0_31ck154 = 1.1 time = 775
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=775.025n

* CHECK dout0_0 Vdout0_0ck159 = 1.1 time = 800
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=800.025n

* CHECK dout0_1 Vdout0_1ck159 = 1.1 time = 800
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=800.025n

* CHECK dout0_2 Vdout0_2ck159 = 1.1 time = 800
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=800.025n

* CHECK dout0_3 Vdout0_3ck159 = 0 time = 800
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=800.025n

* CHECK dout0_4 Vdout0_4ck159 = 0 time = 800
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=800.025n

* CHECK dout0_5 Vdout0_5ck159 = 0 time = 800
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=800.025n

* CHECK dout0_6 Vdout0_6ck159 = 1.1 time = 800
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=800.025n

* CHECK dout0_7 Vdout0_7ck159 = 1.1 time = 800
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=800.025n

* CHECK dout0_8 Vdout0_8ck159 = 0 time = 800
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=800.025n

* CHECK dout0_9 Vdout0_9ck159 = 0 time = 800
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=800.025n

* CHECK dout0_10 Vdout0_10ck159 = 1.1 time = 800
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=800.025n

* CHECK dout0_11 Vdout0_11ck159 = 1.1 time = 800
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=800.025n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 800
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=800.025n

* CHECK dout0_13 Vdout0_13ck159 = 1.1 time = 800
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=800.025n

* CHECK dout0_14 Vdout0_14ck159 = 1.1 time = 800
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=800.025n

* CHECK dout0_15 Vdout0_15ck159 = 0 time = 800
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=800.025n

* CHECK dout0_16 Vdout0_16ck159 = 0 time = 800
.meas tran vdout0_16ck159 FIND v(dout0_16) AT=800.025n

* CHECK dout0_17 Vdout0_17ck159 = 0 time = 800
.meas tran vdout0_17ck159 FIND v(dout0_17) AT=800.025n

* CHECK dout0_18 Vdout0_18ck159 = 0 time = 800
.meas tran vdout0_18ck159 FIND v(dout0_18) AT=800.025n

* CHECK dout0_19 Vdout0_19ck159 = 0 time = 800
.meas tran vdout0_19ck159 FIND v(dout0_19) AT=800.025n

* CHECK dout0_20 Vdout0_20ck159 = 0 time = 800
.meas tran vdout0_20ck159 FIND v(dout0_20) AT=800.025n

* CHECK dout0_21 Vdout0_21ck159 = 1.1 time = 800
.meas tran vdout0_21ck159 FIND v(dout0_21) AT=800.025n

* CHECK dout0_22 Vdout0_22ck159 = 0 time = 800
.meas tran vdout0_22ck159 FIND v(dout0_22) AT=800.025n

* CHECK dout0_23 Vdout0_23ck159 = 0 time = 800
.meas tran vdout0_23ck159 FIND v(dout0_23) AT=800.025n

* CHECK dout0_24 Vdout0_24ck159 = 0 time = 800
.meas tran vdout0_24ck159 FIND v(dout0_24) AT=800.025n

* CHECK dout0_25 Vdout0_25ck159 = 0 time = 800
.meas tran vdout0_25ck159 FIND v(dout0_25) AT=800.025n

* CHECK dout0_26 Vdout0_26ck159 = 0 time = 800
.meas tran vdout0_26ck159 FIND v(dout0_26) AT=800.025n

* CHECK dout0_27 Vdout0_27ck159 = 1.1 time = 800
.meas tran vdout0_27ck159 FIND v(dout0_27) AT=800.025n

* CHECK dout0_28 Vdout0_28ck159 = 0 time = 800
.meas tran vdout0_28ck159 FIND v(dout0_28) AT=800.025n

* CHECK dout0_29 Vdout0_29ck159 = 1.1 time = 800
.meas tran vdout0_29ck159 FIND v(dout0_29) AT=800.025n

* CHECK dout0_30 Vdout0_30ck159 = 1.1 time = 800
.meas tran vdout0_30ck159 FIND v(dout0_30) AT=800.025n

* CHECK dout0_31 Vdout0_31ck159 = 0 time = 800
.meas tran vdout0_31ck159 FIND v(dout0_31) AT=800.025n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 805
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=805.025n

* CHECK dout0_1 Vdout0_1ck160 = 1.1 time = 805
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=805.025n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 805
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=805.025n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 805
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=805.025n

* CHECK dout0_4 Vdout0_4ck160 = 1.1 time = 805
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=805.025n

* CHECK dout0_5 Vdout0_5ck160 = 0 time = 805
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=805.025n

* CHECK dout0_6 Vdout0_6ck160 = 1.1 time = 805
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=805.025n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 805
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=805.025n

* CHECK dout0_8 Vdout0_8ck160 = 0 time = 805
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=805.025n

* CHECK dout0_9 Vdout0_9ck160 = 1.1 time = 805
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=805.025n

* CHECK dout0_10 Vdout0_10ck160 = 0 time = 805
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=805.025n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 805
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=805.025n

* CHECK dout0_12 Vdout0_12ck160 = 1.1 time = 805
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=805.025n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 805
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=805.025n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 805
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=805.025n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 805
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=805.025n

* CHECK dout0_16 Vdout0_16ck160 = 1.1 time = 805
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=805.025n

* CHECK dout0_17 Vdout0_17ck160 = 1.1 time = 805
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=805.025n

* CHECK dout0_18 Vdout0_18ck160 = 0 time = 805
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=805.025n

* CHECK dout0_19 Vdout0_19ck160 = 1.1 time = 805
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=805.025n

* CHECK dout0_20 Vdout0_20ck160 = 0 time = 805
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=805.025n

* CHECK dout0_21 Vdout0_21ck160 = 0 time = 805
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=805.025n

* CHECK dout0_22 Vdout0_22ck160 = 0 time = 805
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=805.025n

* CHECK dout0_23 Vdout0_23ck160 = 1.1 time = 805
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=805.025n

* CHECK dout0_24 Vdout0_24ck160 = 1.1 time = 805
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=805.025n

* CHECK dout0_25 Vdout0_25ck160 = 0 time = 805
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=805.025n

* CHECK dout0_26 Vdout0_26ck160 = 0 time = 805
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=805.025n

* CHECK dout0_27 Vdout0_27ck160 = 0 time = 805
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=805.025n

* CHECK dout0_28 Vdout0_28ck160 = 1.1 time = 805
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=805.025n

* CHECK dout0_29 Vdout0_29ck160 = 1.1 time = 805
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=805.025n

* CHECK dout0_30 Vdout0_30ck160 = 1.1 time = 805
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=805.025n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 805
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=805.025n

* CHECK dout0_0 Vdout0_0ck161 = 0 time = 810
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=810.025n

* CHECK dout0_1 Vdout0_1ck161 = 1.1 time = 810
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=810.025n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 810
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=810.025n

* CHECK dout0_3 Vdout0_3ck161 = 1.1 time = 810
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=810.025n

* CHECK dout0_4 Vdout0_4ck161 = 1.1 time = 810
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=810.025n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 810
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=810.025n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 810
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=810.025n

* CHECK dout0_7 Vdout0_7ck161 = 1.1 time = 810
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=810.025n

* CHECK dout0_8 Vdout0_8ck161 = 0 time = 810
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=810.025n

* CHECK dout0_9 Vdout0_9ck161 = 1.1 time = 810
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=810.025n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 810
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=810.025n

* CHECK dout0_11 Vdout0_11ck161 = 1.1 time = 810
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=810.025n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 810
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=810.025n

* CHECK dout0_13 Vdout0_13ck161 = 1.1 time = 810
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=810.025n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 810
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=810.025n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 810
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=810.025n

* CHECK dout0_16 Vdout0_16ck161 = 1.1 time = 810
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=810.025n

* CHECK dout0_17 Vdout0_17ck161 = 1.1 time = 810
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=810.025n

* CHECK dout0_18 Vdout0_18ck161 = 1.1 time = 810
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=810.025n

* CHECK dout0_19 Vdout0_19ck161 = 0 time = 810
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=810.025n

* CHECK dout0_20 Vdout0_20ck161 = 0 time = 810
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=810.025n

* CHECK dout0_21 Vdout0_21ck161 = 1.1 time = 810
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=810.025n

* CHECK dout0_22 Vdout0_22ck161 = 0 time = 810
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=810.025n

* CHECK dout0_23 Vdout0_23ck161 = 0 time = 810
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=810.025n

* CHECK dout0_24 Vdout0_24ck161 = 0 time = 810
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=810.025n

* CHECK dout0_25 Vdout0_25ck161 = 0 time = 810
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=810.025n

* CHECK dout0_26 Vdout0_26ck161 = 1.1 time = 810
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=810.025n

* CHECK dout0_27 Vdout0_27ck161 = 0 time = 810
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=810.025n

* CHECK dout0_28 Vdout0_28ck161 = 1.1 time = 810
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=810.025n

* CHECK dout0_29 Vdout0_29ck161 = 0 time = 810
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=810.025n

* CHECK dout0_30 Vdout0_30ck161 = 0 time = 810
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=810.025n

* CHECK dout0_31 Vdout0_31ck161 = 1.1 time = 810
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=810.025n

* CHECK dout0_0 Vdout0_0ck163 = 0 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 0 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 1.1 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 1.1 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 1.1 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 1.1 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 1.1 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 1.1 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 0 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 1.1 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 1.1 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 1.1 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 1.1 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 1.1 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 1.1 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 1.1 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 0 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 1.1 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 0 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 0 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 1.1 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 1.1 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 1.1 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 0 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 1.1 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_0 Vdout0_0ck164 = 0 time = 825
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=825.025n

* CHECK dout0_1 Vdout0_1ck164 = 0 time = 825
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=825.025n

* CHECK dout0_2 Vdout0_2ck164 = 1.1 time = 825
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=825.025n

* CHECK dout0_3 Vdout0_3ck164 = 1.1 time = 825
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=825.025n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 825
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=825.025n

* CHECK dout0_5 Vdout0_5ck164 = 1.1 time = 825
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=825.025n

* CHECK dout0_6 Vdout0_6ck164 = 1.1 time = 825
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=825.025n

* CHECK dout0_7 Vdout0_7ck164 = 1.1 time = 825
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=825.025n

* CHECK dout0_8 Vdout0_8ck164 = 1.1 time = 825
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=825.025n

* CHECK dout0_9 Vdout0_9ck164 = 0 time = 825
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=825.025n

* CHECK dout0_10 Vdout0_10ck164 = 1.1 time = 825
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=825.025n

* CHECK dout0_11 Vdout0_11ck164 = 0 time = 825
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=825.025n

* CHECK dout0_12 Vdout0_12ck164 = 1.1 time = 825
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=825.025n

* CHECK dout0_13 Vdout0_13ck164 = 1.1 time = 825
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=825.025n

* CHECK dout0_14 Vdout0_14ck164 = 0 time = 825
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=825.025n

* CHECK dout0_15 Vdout0_15ck164 = 1.1 time = 825
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=825.025n

* CHECK dout0_16 Vdout0_16ck164 = 1.1 time = 825
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=825.025n

* CHECK dout0_17 Vdout0_17ck164 = 1.1 time = 825
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=825.025n

* CHECK dout0_18 Vdout0_18ck164 = 1.1 time = 825
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=825.025n

* CHECK dout0_19 Vdout0_19ck164 = 0 time = 825
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=825.025n

* CHECK dout0_20 Vdout0_20ck164 = 0 time = 825
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=825.025n

* CHECK dout0_21 Vdout0_21ck164 = 0 time = 825
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=825.025n

* CHECK dout0_22 Vdout0_22ck164 = 0 time = 825
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=825.025n

* CHECK dout0_23 Vdout0_23ck164 = 1.1 time = 825
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=825.025n

* CHECK dout0_24 Vdout0_24ck164 = 0 time = 825
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=825.025n

* CHECK dout0_25 Vdout0_25ck164 = 0 time = 825
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=825.025n

* CHECK dout0_26 Vdout0_26ck164 = 0 time = 825
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=825.025n

* CHECK dout0_27 Vdout0_27ck164 = 1.1 time = 825
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=825.025n

* CHECK dout0_28 Vdout0_28ck164 = 1.1 time = 825
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=825.025n

* CHECK dout0_29 Vdout0_29ck164 = 1.1 time = 825
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=825.025n

* CHECK dout0_30 Vdout0_30ck164 = 0 time = 825
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=825.025n

* CHECK dout0_31 Vdout0_31ck164 = 1.1 time = 825
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=825.025n

* CHECK dout0_0 Vdout0_0ck165 = 1.1 time = 830
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=830.025n

* CHECK dout0_1 Vdout0_1ck165 = 1.1 time = 830
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=830.025n

* CHECK dout0_2 Vdout0_2ck165 = 1.1 time = 830
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=830.025n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 830
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=830.025n

* CHECK dout0_4 Vdout0_4ck165 = 1.1 time = 830
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=830.025n

* CHECK dout0_5 Vdout0_5ck165 = 1.1 time = 830
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=830.025n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 830
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=830.025n

* CHECK dout0_7 Vdout0_7ck165 = 0 time = 830
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=830.025n

* CHECK dout0_8 Vdout0_8ck165 = 1.1 time = 830
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=830.025n

* CHECK dout0_9 Vdout0_9ck165 = 1.1 time = 830
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=830.025n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 830
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=830.025n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 830
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=830.025n

* CHECK dout0_12 Vdout0_12ck165 = 0 time = 830
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=830.025n

* CHECK dout0_13 Vdout0_13ck165 = 1.1 time = 830
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=830.025n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 830
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=830.025n

* CHECK dout0_15 Vdout0_15ck165 = 1.1 time = 830
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=830.025n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 830
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=830.025n

* CHECK dout0_17 Vdout0_17ck165 = 1.1 time = 830
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=830.025n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 830
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=830.025n

* CHECK dout0_19 Vdout0_19ck165 = 0 time = 830
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=830.025n

* CHECK dout0_20 Vdout0_20ck165 = 0 time = 830
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=830.025n

* CHECK dout0_21 Vdout0_21ck165 = 0 time = 830
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=830.025n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 830
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=830.025n

* CHECK dout0_23 Vdout0_23ck165 = 0 time = 830
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=830.025n

* CHECK dout0_24 Vdout0_24ck165 = 1.1 time = 830
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=830.025n

* CHECK dout0_25 Vdout0_25ck165 = 0 time = 830
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=830.025n

* CHECK dout0_26 Vdout0_26ck165 = 1.1 time = 830
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=830.025n

* CHECK dout0_27 Vdout0_27ck165 = 1.1 time = 830
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=830.025n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 830
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=830.025n

* CHECK dout0_29 Vdout0_29ck165 = 1.1 time = 830
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=830.025n

* CHECK dout0_30 Vdout0_30ck165 = 0 time = 830
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=830.025n

* CHECK dout0_31 Vdout0_31ck165 = 1.1 time = 830
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=830.025n

* CHECK dout0_0 Vdout0_0ck166 = 1.1 time = 835
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=835.025n

* CHECK dout0_1 Vdout0_1ck166 = 1.1 time = 835
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=835.025n

* CHECK dout0_2 Vdout0_2ck166 = 1.1 time = 835
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=835.025n

* CHECK dout0_3 Vdout0_3ck166 = 0 time = 835
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=835.025n

* CHECK dout0_4 Vdout0_4ck166 = 1.1 time = 835
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=835.025n

* CHECK dout0_5 Vdout0_5ck166 = 1.1 time = 835
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=835.025n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 835
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=835.025n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 835
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=835.025n

* CHECK dout0_8 Vdout0_8ck166 = 1.1 time = 835
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=835.025n

* CHECK dout0_9 Vdout0_9ck166 = 1.1 time = 835
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=835.025n

* CHECK dout0_10 Vdout0_10ck166 = 0 time = 835
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=835.025n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 835
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=835.025n

* CHECK dout0_12 Vdout0_12ck166 = 0 time = 835
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=835.025n

* CHECK dout0_13 Vdout0_13ck166 = 1.1 time = 835
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=835.025n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 835
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=835.025n

* CHECK dout0_15 Vdout0_15ck166 = 1.1 time = 835
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=835.025n

* CHECK dout0_16 Vdout0_16ck166 = 0 time = 835
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=835.025n

* CHECK dout0_17 Vdout0_17ck166 = 1.1 time = 835
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=835.025n

* CHECK dout0_18 Vdout0_18ck166 = 0 time = 835
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=835.025n

* CHECK dout0_19 Vdout0_19ck166 = 0 time = 835
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=835.025n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 835
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=835.025n

* CHECK dout0_21 Vdout0_21ck166 = 0 time = 835
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=835.025n

* CHECK dout0_22 Vdout0_22ck166 = 0 time = 835
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=835.025n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 835
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=835.025n

* CHECK dout0_24 Vdout0_24ck166 = 1.1 time = 835
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=835.025n

* CHECK dout0_25 Vdout0_25ck166 = 0 time = 835
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=835.025n

* CHECK dout0_26 Vdout0_26ck166 = 1.1 time = 835
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=835.025n

* CHECK dout0_27 Vdout0_27ck166 = 1.1 time = 835
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=835.025n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 835
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=835.025n

* CHECK dout0_29 Vdout0_29ck166 = 1.1 time = 835
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=835.025n

* CHECK dout0_30 Vdout0_30ck166 = 0 time = 835
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=835.025n

* CHECK dout0_31 Vdout0_31ck166 = 1.1 time = 835
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=835.025n

* CHECK dout0_0 Vdout0_0ck167 = 1.1 time = 840
.meas tran vdout0_0ck167 FIND v(dout0_0) AT=840.025n

* CHECK dout0_1 Vdout0_1ck167 = 1.1 time = 840
.meas tran vdout0_1ck167 FIND v(dout0_1) AT=840.025n

* CHECK dout0_2 Vdout0_2ck167 = 1.1 time = 840
.meas tran vdout0_2ck167 FIND v(dout0_2) AT=840.025n

* CHECK dout0_3 Vdout0_3ck167 = 0 time = 840
.meas tran vdout0_3ck167 FIND v(dout0_3) AT=840.025n

* CHECK dout0_4 Vdout0_4ck167 = 1.1 time = 840
.meas tran vdout0_4ck167 FIND v(dout0_4) AT=840.025n

* CHECK dout0_5 Vdout0_5ck167 = 1.1 time = 840
.meas tran vdout0_5ck167 FIND v(dout0_5) AT=840.025n

* CHECK dout0_6 Vdout0_6ck167 = 0 time = 840
.meas tran vdout0_6ck167 FIND v(dout0_6) AT=840.025n

* CHECK dout0_7 Vdout0_7ck167 = 0 time = 840
.meas tran vdout0_7ck167 FIND v(dout0_7) AT=840.025n

* CHECK dout0_8 Vdout0_8ck167 = 1.1 time = 840
.meas tran vdout0_8ck167 FIND v(dout0_8) AT=840.025n

* CHECK dout0_9 Vdout0_9ck167 = 1.1 time = 840
.meas tran vdout0_9ck167 FIND v(dout0_9) AT=840.025n

* CHECK dout0_10 Vdout0_10ck167 = 0 time = 840
.meas tran vdout0_10ck167 FIND v(dout0_10) AT=840.025n

* CHECK dout0_11 Vdout0_11ck167 = 0 time = 840
.meas tran vdout0_11ck167 FIND v(dout0_11) AT=840.025n

* CHECK dout0_12 Vdout0_12ck167 = 0 time = 840
.meas tran vdout0_12ck167 FIND v(dout0_12) AT=840.025n

* CHECK dout0_13 Vdout0_13ck167 = 1.1 time = 840
.meas tran vdout0_13ck167 FIND v(dout0_13) AT=840.025n

* CHECK dout0_14 Vdout0_14ck167 = 0 time = 840
.meas tran vdout0_14ck167 FIND v(dout0_14) AT=840.025n

* CHECK dout0_15 Vdout0_15ck167 = 1.1 time = 840
.meas tran vdout0_15ck167 FIND v(dout0_15) AT=840.025n

* CHECK dout0_16 Vdout0_16ck167 = 0 time = 840
.meas tran vdout0_16ck167 FIND v(dout0_16) AT=840.025n

* CHECK dout0_17 Vdout0_17ck167 = 1.1 time = 840
.meas tran vdout0_17ck167 FIND v(dout0_17) AT=840.025n

* CHECK dout0_18 Vdout0_18ck167 = 0 time = 840
.meas tran vdout0_18ck167 FIND v(dout0_18) AT=840.025n

* CHECK dout0_19 Vdout0_19ck167 = 0 time = 840
.meas tran vdout0_19ck167 FIND v(dout0_19) AT=840.025n

* CHECK dout0_20 Vdout0_20ck167 = 0 time = 840
.meas tran vdout0_20ck167 FIND v(dout0_20) AT=840.025n

* CHECK dout0_21 Vdout0_21ck167 = 0 time = 840
.meas tran vdout0_21ck167 FIND v(dout0_21) AT=840.025n

* CHECK dout0_22 Vdout0_22ck167 = 0 time = 840
.meas tran vdout0_22ck167 FIND v(dout0_22) AT=840.025n

* CHECK dout0_23 Vdout0_23ck167 = 0 time = 840
.meas tran vdout0_23ck167 FIND v(dout0_23) AT=840.025n

* CHECK dout0_24 Vdout0_24ck167 = 1.1 time = 840
.meas tran vdout0_24ck167 FIND v(dout0_24) AT=840.025n

* CHECK dout0_25 Vdout0_25ck167 = 0 time = 840
.meas tran vdout0_25ck167 FIND v(dout0_25) AT=840.025n

* CHECK dout0_26 Vdout0_26ck167 = 1.1 time = 840
.meas tran vdout0_26ck167 FIND v(dout0_26) AT=840.025n

* CHECK dout0_27 Vdout0_27ck167 = 1.1 time = 840
.meas tran vdout0_27ck167 FIND v(dout0_27) AT=840.025n

* CHECK dout0_28 Vdout0_28ck167 = 0 time = 840
.meas tran vdout0_28ck167 FIND v(dout0_28) AT=840.025n

* CHECK dout0_29 Vdout0_29ck167 = 1.1 time = 840
.meas tran vdout0_29ck167 FIND v(dout0_29) AT=840.025n

* CHECK dout0_30 Vdout0_30ck167 = 0 time = 840
.meas tran vdout0_30ck167 FIND v(dout0_30) AT=840.025n

* CHECK dout0_31 Vdout0_31ck167 = 1.1 time = 840
.meas tran vdout0_31ck167 FIND v(dout0_31) AT=840.025n

* CHECK dout0_0 Vdout0_0ck168 = 1.1 time = 845
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=845.025n

* CHECK dout0_1 Vdout0_1ck168 = 1.1 time = 845
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=845.025n

* CHECK dout0_2 Vdout0_2ck168 = 1.1 time = 845
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=845.025n

* CHECK dout0_3 Vdout0_3ck168 = 0 time = 845
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=845.025n

* CHECK dout0_4 Vdout0_4ck168 = 1.1 time = 845
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=845.025n

* CHECK dout0_5 Vdout0_5ck168 = 1.1 time = 845
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=845.025n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 845
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=845.025n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 845
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=845.025n

* CHECK dout0_8 Vdout0_8ck168 = 1.1 time = 845
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=845.025n

* CHECK dout0_9 Vdout0_9ck168 = 1.1 time = 845
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=845.025n

* CHECK dout0_10 Vdout0_10ck168 = 0 time = 845
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=845.025n

* CHECK dout0_11 Vdout0_11ck168 = 0 time = 845
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=845.025n

* CHECK dout0_12 Vdout0_12ck168 = 0 time = 845
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=845.025n

* CHECK dout0_13 Vdout0_13ck168 = 1.1 time = 845
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=845.025n

* CHECK dout0_14 Vdout0_14ck168 = 0 time = 845
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=845.025n

* CHECK dout0_15 Vdout0_15ck168 = 1.1 time = 845
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=845.025n

* CHECK dout0_16 Vdout0_16ck168 = 0 time = 845
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=845.025n

* CHECK dout0_17 Vdout0_17ck168 = 1.1 time = 845
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=845.025n

* CHECK dout0_18 Vdout0_18ck168 = 0 time = 845
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=845.025n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 845
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=845.025n

* CHECK dout0_20 Vdout0_20ck168 = 0 time = 845
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=845.025n

* CHECK dout0_21 Vdout0_21ck168 = 0 time = 845
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=845.025n

* CHECK dout0_22 Vdout0_22ck168 = 0 time = 845
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=845.025n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 845
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=845.025n

* CHECK dout0_24 Vdout0_24ck168 = 1.1 time = 845
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=845.025n

* CHECK dout0_25 Vdout0_25ck168 = 0 time = 845
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=845.025n

* CHECK dout0_26 Vdout0_26ck168 = 1.1 time = 845
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=845.025n

* CHECK dout0_27 Vdout0_27ck168 = 1.1 time = 845
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=845.025n

* CHECK dout0_28 Vdout0_28ck168 = 0 time = 845
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=845.025n

* CHECK dout0_29 Vdout0_29ck168 = 1.1 time = 845
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=845.025n

* CHECK dout0_30 Vdout0_30ck168 = 0 time = 845
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=845.025n

* CHECK dout0_31 Vdout0_31ck168 = 1.1 time = 845
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=845.025n

* CHECK dout0_0 Vdout0_0ck170 = 0 time = 855
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=855.025n

* CHECK dout0_1 Vdout0_1ck170 = 1.1 time = 855
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=855.025n

* CHECK dout0_2 Vdout0_2ck170 = 0 time = 855
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=855.025n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 855
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=855.025n

* CHECK dout0_4 Vdout0_4ck170 = 1.1 time = 855
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=855.025n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 855
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=855.025n

* CHECK dout0_6 Vdout0_6ck170 = 1.1 time = 855
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=855.025n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 855
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=855.025n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 855
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=855.025n

* CHECK dout0_9 Vdout0_9ck170 = 1.1 time = 855
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=855.025n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 855
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=855.025n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 855
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=855.025n

* CHECK dout0_12 Vdout0_12ck170 = 1.1 time = 855
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=855.025n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 855
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=855.025n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 855
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=855.025n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 855
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=855.025n

* CHECK dout0_16 Vdout0_16ck170 = 1.1 time = 855
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=855.025n

* CHECK dout0_17 Vdout0_17ck170 = 1.1 time = 855
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=855.025n

* CHECK dout0_18 Vdout0_18ck170 = 0 time = 855
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=855.025n

* CHECK dout0_19 Vdout0_19ck170 = 1.1 time = 855
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=855.025n

* CHECK dout0_20 Vdout0_20ck170 = 0 time = 855
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=855.025n

* CHECK dout0_21 Vdout0_21ck170 = 0 time = 855
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=855.025n

* CHECK dout0_22 Vdout0_22ck170 = 0 time = 855
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=855.025n

* CHECK dout0_23 Vdout0_23ck170 = 1.1 time = 855
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=855.025n

* CHECK dout0_24 Vdout0_24ck170 = 1.1 time = 855
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=855.025n

* CHECK dout0_25 Vdout0_25ck170 = 0 time = 855
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=855.025n

* CHECK dout0_26 Vdout0_26ck170 = 0 time = 855
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=855.025n

* CHECK dout0_27 Vdout0_27ck170 = 0 time = 855
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=855.025n

* CHECK dout0_28 Vdout0_28ck170 = 1.1 time = 855
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=855.025n

* CHECK dout0_29 Vdout0_29ck170 = 1.1 time = 855
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=855.025n

* CHECK dout0_30 Vdout0_30ck170 = 1.1 time = 855
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=855.025n

* CHECK dout0_31 Vdout0_31ck170 = 0 time = 855
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=855.025n

* CHECK dout0_0 Vdout0_0ck171 = 1.1 time = 860
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=860.025n

* CHECK dout0_1 Vdout0_1ck171 = 1.1 time = 860
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=860.025n

* CHECK dout0_2 Vdout0_2ck171 = 1.1 time = 860
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=860.025n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 860
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=860.025n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 860
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=860.025n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 860
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=860.025n

* CHECK dout0_6 Vdout0_6ck171 = 1.1 time = 860
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=860.025n

* CHECK dout0_7 Vdout0_7ck171 = 1.1 time = 860
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=860.025n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 860
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=860.025n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 860
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=860.025n

* CHECK dout0_10 Vdout0_10ck171 = 1.1 time = 860
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=860.025n

* CHECK dout0_11 Vdout0_11ck171 = 1.1 time = 860
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=860.025n

* CHECK dout0_12 Vdout0_12ck171 = 0 time = 860
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=860.025n

* CHECK dout0_13 Vdout0_13ck171 = 1.1 time = 860
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=860.025n

* CHECK dout0_14 Vdout0_14ck171 = 1.1 time = 860
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=860.025n

* CHECK dout0_15 Vdout0_15ck171 = 0 time = 860
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=860.025n

* CHECK dout0_16 Vdout0_16ck171 = 0 time = 860
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=860.025n

* CHECK dout0_17 Vdout0_17ck171 = 0 time = 860
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=860.025n

* CHECK dout0_18 Vdout0_18ck171 = 0 time = 860
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=860.025n

* CHECK dout0_19 Vdout0_19ck171 = 0 time = 860
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=860.025n

* CHECK dout0_20 Vdout0_20ck171 = 0 time = 860
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=860.025n

* CHECK dout0_21 Vdout0_21ck171 = 1.1 time = 860
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=860.025n

* CHECK dout0_22 Vdout0_22ck171 = 0 time = 860
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=860.025n

* CHECK dout0_23 Vdout0_23ck171 = 0 time = 860
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=860.025n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 860
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=860.025n

* CHECK dout0_25 Vdout0_25ck171 = 0 time = 860
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=860.025n

* CHECK dout0_26 Vdout0_26ck171 = 0 time = 860
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=860.025n

* CHECK dout0_27 Vdout0_27ck171 = 1.1 time = 860
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=860.025n

* CHECK dout0_28 Vdout0_28ck171 = 0 time = 860
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=860.025n

* CHECK dout0_29 Vdout0_29ck171 = 1.1 time = 860
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=860.025n

* CHECK dout0_30 Vdout0_30ck171 = 1.1 time = 860
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=860.025n

* CHECK dout0_31 Vdout0_31ck171 = 0 time = 860
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=860.025n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 865
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=865.025n

* CHECK dout0_1 Vdout0_1ck172 = 1.1 time = 865
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=865.025n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 865
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=865.025n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 865
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=865.025n

* CHECK dout0_4 Vdout0_4ck172 = 1.1 time = 865
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=865.025n

* CHECK dout0_5 Vdout0_5ck172 = 0 time = 865
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=865.025n

* CHECK dout0_6 Vdout0_6ck172 = 1.1 time = 865
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=865.025n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 865
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=865.025n

* CHECK dout0_8 Vdout0_8ck172 = 0 time = 865
.meas tran vdout0_8ck172 FIND v(dout0_8) AT=865.025n

* CHECK dout0_9 Vdout0_9ck172 = 1.1 time = 865
.meas tran vdout0_9ck172 FIND v(dout0_9) AT=865.025n

* CHECK dout0_10 Vdout0_10ck172 = 0 time = 865
.meas tran vdout0_10ck172 FIND v(dout0_10) AT=865.025n

* CHECK dout0_11 Vdout0_11ck172 = 0 time = 865
.meas tran vdout0_11ck172 FIND v(dout0_11) AT=865.025n

* CHECK dout0_12 Vdout0_12ck172 = 1.1 time = 865
.meas tran vdout0_12ck172 FIND v(dout0_12) AT=865.025n

* CHECK dout0_13 Vdout0_13ck172 = 0 time = 865
.meas tran vdout0_13ck172 FIND v(dout0_13) AT=865.025n

* CHECK dout0_14 Vdout0_14ck172 = 0 time = 865
.meas tran vdout0_14ck172 FIND v(dout0_14) AT=865.025n

* CHECK dout0_15 Vdout0_15ck172 = 0 time = 865
.meas tran vdout0_15ck172 FIND v(dout0_15) AT=865.025n

* CHECK dout0_16 Vdout0_16ck172 = 1.1 time = 865
.meas tran vdout0_16ck172 FIND v(dout0_16) AT=865.025n

* CHECK dout0_17 Vdout0_17ck172 = 1.1 time = 865
.meas tran vdout0_17ck172 FIND v(dout0_17) AT=865.025n

* CHECK dout0_18 Vdout0_18ck172 = 0 time = 865
.meas tran vdout0_18ck172 FIND v(dout0_18) AT=865.025n

* CHECK dout0_19 Vdout0_19ck172 = 1.1 time = 865
.meas tran vdout0_19ck172 FIND v(dout0_19) AT=865.025n

* CHECK dout0_20 Vdout0_20ck172 = 0 time = 865
.meas tran vdout0_20ck172 FIND v(dout0_20) AT=865.025n

* CHECK dout0_21 Vdout0_21ck172 = 0 time = 865
.meas tran vdout0_21ck172 FIND v(dout0_21) AT=865.025n

* CHECK dout0_22 Vdout0_22ck172 = 0 time = 865
.meas tran vdout0_22ck172 FIND v(dout0_22) AT=865.025n

* CHECK dout0_23 Vdout0_23ck172 = 1.1 time = 865
.meas tran vdout0_23ck172 FIND v(dout0_23) AT=865.025n

* CHECK dout0_24 Vdout0_24ck172 = 1.1 time = 865
.meas tran vdout0_24ck172 FIND v(dout0_24) AT=865.025n

* CHECK dout0_25 Vdout0_25ck172 = 0 time = 865
.meas tran vdout0_25ck172 FIND v(dout0_25) AT=865.025n

* CHECK dout0_26 Vdout0_26ck172 = 0 time = 865
.meas tran vdout0_26ck172 FIND v(dout0_26) AT=865.025n

* CHECK dout0_27 Vdout0_27ck172 = 0 time = 865
.meas tran vdout0_27ck172 FIND v(dout0_27) AT=865.025n

* CHECK dout0_28 Vdout0_28ck172 = 1.1 time = 865
.meas tran vdout0_28ck172 FIND v(dout0_28) AT=865.025n

* CHECK dout0_29 Vdout0_29ck172 = 1.1 time = 865
.meas tran vdout0_29ck172 FIND v(dout0_29) AT=865.025n

* CHECK dout0_30 Vdout0_30ck172 = 1.1 time = 865
.meas tran vdout0_30ck172 FIND v(dout0_30) AT=865.025n

* CHECK dout0_31 Vdout0_31ck172 = 0 time = 865
.meas tran vdout0_31ck172 FIND v(dout0_31) AT=865.025n

* CHECK dout0_0 Vdout0_0ck177 = 0 time = 890
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=890.025n

* CHECK dout0_1 Vdout0_1ck177 = 0 time = 890
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=890.025n

* CHECK dout0_2 Vdout0_2ck177 = 1.1 time = 890
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=890.025n

* CHECK dout0_3 Vdout0_3ck177 = 0 time = 890
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=890.025n

* CHECK dout0_4 Vdout0_4ck177 = 1.1 time = 890
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=890.025n

* CHECK dout0_5 Vdout0_5ck177 = 1.1 time = 890
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=890.025n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 890
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=890.025n

* CHECK dout0_7 Vdout0_7ck177 = 0 time = 890
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=890.025n

* CHECK dout0_8 Vdout0_8ck177 = 0 time = 890
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=890.025n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 890
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=890.025n

* CHECK dout0_10 Vdout0_10ck177 = 0 time = 890
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=890.025n

* CHECK dout0_11 Vdout0_11ck177 = 1.1 time = 890
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=890.025n

* CHECK dout0_12 Vdout0_12ck177 = 0 time = 890
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=890.025n

* CHECK dout0_13 Vdout0_13ck177 = 1.1 time = 890
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=890.025n

* CHECK dout0_14 Vdout0_14ck177 = 1.1 time = 890
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=890.025n

* CHECK dout0_15 Vdout0_15ck177 = 1.1 time = 890
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=890.025n

* CHECK dout0_16 Vdout0_16ck177 = 0 time = 890
.meas tran vdout0_16ck177 FIND v(dout0_16) AT=890.025n

* CHECK dout0_17 Vdout0_17ck177 = 1.1 time = 890
.meas tran vdout0_17ck177 FIND v(dout0_17) AT=890.025n

* CHECK dout0_18 Vdout0_18ck177 = 0 time = 890
.meas tran vdout0_18ck177 FIND v(dout0_18) AT=890.025n

* CHECK dout0_19 Vdout0_19ck177 = 0 time = 890
.meas tran vdout0_19ck177 FIND v(dout0_19) AT=890.025n

* CHECK dout0_20 Vdout0_20ck177 = 1.1 time = 890
.meas tran vdout0_20ck177 FIND v(dout0_20) AT=890.025n

* CHECK dout0_21 Vdout0_21ck177 = 0 time = 890
.meas tran vdout0_21ck177 FIND v(dout0_21) AT=890.025n

* CHECK dout0_22 Vdout0_22ck177 = 1.1 time = 890
.meas tran vdout0_22ck177 FIND v(dout0_22) AT=890.025n

* CHECK dout0_23 Vdout0_23ck177 = 1.1 time = 890
.meas tran vdout0_23ck177 FIND v(dout0_23) AT=890.025n

* CHECK dout0_24 Vdout0_24ck177 = 0 time = 890
.meas tran vdout0_24ck177 FIND v(dout0_24) AT=890.025n

* CHECK dout0_25 Vdout0_25ck177 = 1.1 time = 890
.meas tran vdout0_25ck177 FIND v(dout0_25) AT=890.025n

* CHECK dout0_26 Vdout0_26ck177 = 1.1 time = 890
.meas tran vdout0_26ck177 FIND v(dout0_26) AT=890.025n

* CHECK dout0_27 Vdout0_27ck177 = 0 time = 890
.meas tran vdout0_27ck177 FIND v(dout0_27) AT=890.025n

* CHECK dout0_28 Vdout0_28ck177 = 1.1 time = 890
.meas tran vdout0_28ck177 FIND v(dout0_28) AT=890.025n

* CHECK dout0_29 Vdout0_29ck177 = 0 time = 890
.meas tran vdout0_29ck177 FIND v(dout0_29) AT=890.025n

* CHECK dout0_30 Vdout0_30ck177 = 0 time = 890
.meas tran vdout0_30ck177 FIND v(dout0_30) AT=890.025n

* CHECK dout0_31 Vdout0_31ck177 = 0 time = 890
.meas tran vdout0_31ck177 FIND v(dout0_31) AT=890.025n

* CHECK dout0_0 Vdout0_0ck178 = 1.1 time = 895
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=895.025n

* CHECK dout0_1 Vdout0_1ck178 = 1.1 time = 895
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=895.025n

* CHECK dout0_2 Vdout0_2ck178 = 1.1 time = 895
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=895.025n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 895
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=895.025n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 895
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=895.025n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 895
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=895.025n

* CHECK dout0_6 Vdout0_6ck178 = 1.1 time = 895
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=895.025n

* CHECK dout0_7 Vdout0_7ck178 = 1.1 time = 895
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=895.025n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 895
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=895.025n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 895
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=895.025n

* CHECK dout0_10 Vdout0_10ck178 = 1.1 time = 895
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=895.025n

* CHECK dout0_11 Vdout0_11ck178 = 1.1 time = 895
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=895.025n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 895
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=895.025n

* CHECK dout0_13 Vdout0_13ck178 = 1.1 time = 895
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=895.025n

* CHECK dout0_14 Vdout0_14ck178 = 1.1 time = 895
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=895.025n

* CHECK dout0_15 Vdout0_15ck178 = 0 time = 895
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=895.025n

* CHECK dout0_16 Vdout0_16ck178 = 0 time = 895
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=895.025n

* CHECK dout0_17 Vdout0_17ck178 = 0 time = 895
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=895.025n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 895
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=895.025n

* CHECK dout0_19 Vdout0_19ck178 = 0 time = 895
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=895.025n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 895
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=895.025n

* CHECK dout0_21 Vdout0_21ck178 = 1.1 time = 895
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=895.025n

* CHECK dout0_22 Vdout0_22ck178 = 0 time = 895
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=895.025n

* CHECK dout0_23 Vdout0_23ck178 = 0 time = 895
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=895.025n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 895
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=895.025n

* CHECK dout0_25 Vdout0_25ck178 = 0 time = 895
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=895.025n

* CHECK dout0_26 Vdout0_26ck178 = 0 time = 895
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=895.025n

* CHECK dout0_27 Vdout0_27ck178 = 1.1 time = 895
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=895.025n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 895
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=895.025n

* CHECK dout0_29 Vdout0_29ck178 = 1.1 time = 895
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=895.025n

* CHECK dout0_30 Vdout0_30ck178 = 1.1 time = 895
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=895.025n

* CHECK dout0_31 Vdout0_31ck178 = 0 time = 895
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=895.025n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 910
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=910.025n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 910
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=910.025n

* CHECK dout0_2 Vdout0_2ck181 = 1.1 time = 910
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=910.025n

* CHECK dout0_3 Vdout0_3ck181 = 0 time = 910
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=910.025n

* CHECK dout0_4 Vdout0_4ck181 = 1.1 time = 910
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=910.025n

* CHECK dout0_5 Vdout0_5ck181 = 1.1 time = 910
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=910.025n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 910
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=910.025n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 910
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=910.025n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 910
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=910.025n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 910
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=910.025n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 910
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=910.025n

* CHECK dout0_11 Vdout0_11ck181 = 1.1 time = 910
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=910.025n

* CHECK dout0_12 Vdout0_12ck181 = 0 time = 910
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=910.025n

* CHECK dout0_13 Vdout0_13ck181 = 1.1 time = 910
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=910.025n

* CHECK dout0_14 Vdout0_14ck181 = 1.1 time = 910
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=910.025n

* CHECK dout0_15 Vdout0_15ck181 = 1.1 time = 910
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=910.025n

* CHECK dout0_16 Vdout0_16ck181 = 0 time = 910
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=910.025n

* CHECK dout0_17 Vdout0_17ck181 = 1.1 time = 910
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=910.025n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 910
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=910.025n

* CHECK dout0_19 Vdout0_19ck181 = 0 time = 910
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=910.025n

* CHECK dout0_20 Vdout0_20ck181 = 1.1 time = 910
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=910.025n

* CHECK dout0_21 Vdout0_21ck181 = 0 time = 910
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=910.025n

* CHECK dout0_22 Vdout0_22ck181 = 1.1 time = 910
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=910.025n

* CHECK dout0_23 Vdout0_23ck181 = 1.1 time = 910
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=910.025n

* CHECK dout0_24 Vdout0_24ck181 = 0 time = 910
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=910.025n

* CHECK dout0_25 Vdout0_25ck181 = 1.1 time = 910
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=910.025n

* CHECK dout0_26 Vdout0_26ck181 = 1.1 time = 910
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=910.025n

* CHECK dout0_27 Vdout0_27ck181 = 0 time = 910
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=910.025n

* CHECK dout0_28 Vdout0_28ck181 = 1.1 time = 910
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=910.025n

* CHECK dout0_29 Vdout0_29ck181 = 0 time = 910
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=910.025n

* CHECK dout0_30 Vdout0_30ck181 = 0 time = 910
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=910.025n

* CHECK dout0_31 Vdout0_31ck181 = 0 time = 910
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=910.025n

* CHECK dout0_0 Vdout0_0ck182 = 0 time = 915
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=915.025n

* CHECK dout0_1 Vdout0_1ck182 = 1.1 time = 915
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=915.025n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 915
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=915.025n

* CHECK dout0_3 Vdout0_3ck182 = 1.1 time = 915
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=915.025n

* CHECK dout0_4 Vdout0_4ck182 = 1.1 time = 915
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=915.025n

* CHECK dout0_5 Vdout0_5ck182 = 1.1 time = 915
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=915.025n

* CHECK dout0_6 Vdout0_6ck182 = 1.1 time = 915
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=915.025n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 915
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=915.025n

* CHECK dout0_8 Vdout0_8ck182 = 1.1 time = 915
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=915.025n

* CHECK dout0_9 Vdout0_9ck182 = 1.1 time = 915
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=915.025n

* CHECK dout0_10 Vdout0_10ck182 = 0 time = 915
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=915.025n

* CHECK dout0_11 Vdout0_11ck182 = 0 time = 915
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=915.025n

* CHECK dout0_12 Vdout0_12ck182 = 1.1 time = 915
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=915.025n

* CHECK dout0_13 Vdout0_13ck182 = 0 time = 915
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=915.025n

* CHECK dout0_14 Vdout0_14ck182 = 0 time = 915
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=915.025n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 915
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=915.025n

* CHECK dout0_16 Vdout0_16ck182 = 0 time = 915
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=915.025n

* CHECK dout0_17 Vdout0_17ck182 = 0 time = 915
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=915.025n

* CHECK dout0_18 Vdout0_18ck182 = 0 time = 915
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=915.025n

* CHECK dout0_19 Vdout0_19ck182 = 0 time = 915
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=915.025n

* CHECK dout0_20 Vdout0_20ck182 = 1.1 time = 915
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=915.025n

* CHECK dout0_21 Vdout0_21ck182 = 0 time = 915
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=915.025n

* CHECK dout0_22 Vdout0_22ck182 = 1.1 time = 915
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=915.025n

* CHECK dout0_23 Vdout0_23ck182 = 0 time = 915
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=915.025n

* CHECK dout0_24 Vdout0_24ck182 = 1.1 time = 915
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=915.025n

* CHECK dout0_25 Vdout0_25ck182 = 0 time = 915
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=915.025n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 915
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=915.025n

* CHECK dout0_27 Vdout0_27ck182 = 1.1 time = 915
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=915.025n

* CHECK dout0_28 Vdout0_28ck182 = 1.1 time = 915
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=915.025n

* CHECK dout0_29 Vdout0_29ck182 = 1.1 time = 915
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=915.025n

* CHECK dout0_30 Vdout0_30ck182 = 0 time = 915
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=915.025n

* CHECK dout0_31 Vdout0_31ck182 = 1.1 time = 915
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=915.025n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 920
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=920.025n

* CHECK dout0_1 Vdout0_1ck183 = 0 time = 920
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=920.025n

* CHECK dout0_2 Vdout0_2ck183 = 1.1 time = 920
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=920.025n

* CHECK dout0_3 Vdout0_3ck183 = 0 time = 920
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=920.025n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 920
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=920.025n

* CHECK dout0_5 Vdout0_5ck183 = 1.1 time = 920
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=920.025n

* CHECK dout0_6 Vdout0_6ck183 = 0 time = 920
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=920.025n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 920
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=920.025n

* CHECK dout0_8 Vdout0_8ck183 = 1.1 time = 920
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=920.025n

* CHECK dout0_9 Vdout0_9ck183 = 1.1 time = 920
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=920.025n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 920
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=920.025n

* CHECK dout0_11 Vdout0_11ck183 = 1.1 time = 920
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=920.025n

* CHECK dout0_12 Vdout0_12ck183 = 1.1 time = 920
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=920.025n

* CHECK dout0_13 Vdout0_13ck183 = 0 time = 920
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=920.025n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 920
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=920.025n

* CHECK dout0_15 Vdout0_15ck183 = 1.1 time = 920
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=920.025n

* CHECK dout0_16 Vdout0_16ck183 = 1.1 time = 920
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=920.025n

* CHECK dout0_17 Vdout0_17ck183 = 0 time = 920
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=920.025n

* CHECK dout0_18 Vdout0_18ck183 = 1.1 time = 920
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=920.025n

* CHECK dout0_19 Vdout0_19ck183 = 0 time = 920
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=920.025n

* CHECK dout0_20 Vdout0_20ck183 = 1.1 time = 920
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=920.025n

* CHECK dout0_21 Vdout0_21ck183 = 1.1 time = 920
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=920.025n

* CHECK dout0_22 Vdout0_22ck183 = 1.1 time = 920
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=920.025n

* CHECK dout0_23 Vdout0_23ck183 = 0 time = 920
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=920.025n

* CHECK dout0_24 Vdout0_24ck183 = 1.1 time = 920
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=920.025n

* CHECK dout0_25 Vdout0_25ck183 = 1.1 time = 920
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=920.025n

* CHECK dout0_26 Vdout0_26ck183 = 1.1 time = 920
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=920.025n

* CHECK dout0_27 Vdout0_27ck183 = 1.1 time = 920
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=920.025n

* CHECK dout0_28 Vdout0_28ck183 = 1.1 time = 920
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=920.025n

* CHECK dout0_29 Vdout0_29ck183 = 0 time = 920
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=920.025n

* CHECK dout0_30 Vdout0_30ck183 = 1.1 time = 920
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=920.025n

* CHECK dout0_31 Vdout0_31ck183 = 0 time = 920
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=920.025n

* CHECK dout0_0 Vdout0_0ck184 = 1.1 time = 925
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=925.025n

* CHECK dout0_1 Vdout0_1ck184 = 1.1 time = 925
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=925.025n

* CHECK dout0_2 Vdout0_2ck184 = 1.1 time = 925
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=925.025n

* CHECK dout0_3 Vdout0_3ck184 = 0 time = 925
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=925.025n

* CHECK dout0_4 Vdout0_4ck184 = 1.1 time = 925
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=925.025n

* CHECK dout0_5 Vdout0_5ck184 = 1.1 time = 925
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=925.025n

* CHECK dout0_6 Vdout0_6ck184 = 0 time = 925
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=925.025n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 925
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=925.025n

* CHECK dout0_8 Vdout0_8ck184 = 1.1 time = 925
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=925.025n

* CHECK dout0_9 Vdout0_9ck184 = 1.1 time = 925
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=925.025n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 925
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=925.025n

* CHECK dout0_11 Vdout0_11ck184 = 0 time = 925
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=925.025n

* CHECK dout0_12 Vdout0_12ck184 = 0 time = 925
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=925.025n

* CHECK dout0_13 Vdout0_13ck184 = 1.1 time = 925
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=925.025n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 925
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=925.025n

* CHECK dout0_15 Vdout0_15ck184 = 1.1 time = 925
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=925.025n

* CHECK dout0_16 Vdout0_16ck184 = 0 time = 925
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=925.025n

* CHECK dout0_17 Vdout0_17ck184 = 1.1 time = 925
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=925.025n

* CHECK dout0_18 Vdout0_18ck184 = 0 time = 925
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=925.025n

* CHECK dout0_19 Vdout0_19ck184 = 0 time = 925
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=925.025n

* CHECK dout0_20 Vdout0_20ck184 = 0 time = 925
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=925.025n

* CHECK dout0_21 Vdout0_21ck184 = 0 time = 925
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=925.025n

* CHECK dout0_22 Vdout0_22ck184 = 0 time = 925
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=925.025n

* CHECK dout0_23 Vdout0_23ck184 = 0 time = 925
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=925.025n

* CHECK dout0_24 Vdout0_24ck184 = 1.1 time = 925
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=925.025n

* CHECK dout0_25 Vdout0_25ck184 = 0 time = 925
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=925.025n

* CHECK dout0_26 Vdout0_26ck184 = 1.1 time = 925
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=925.025n

* CHECK dout0_27 Vdout0_27ck184 = 1.1 time = 925
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=925.025n

* CHECK dout0_28 Vdout0_28ck184 = 0 time = 925
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=925.025n

* CHECK dout0_29 Vdout0_29ck184 = 1.1 time = 925
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=925.025n

* CHECK dout0_30 Vdout0_30ck184 = 0 time = 925
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=925.025n

* CHECK dout0_31 Vdout0_31ck184 = 1.1 time = 925
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=925.025n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 940
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=940.025n

* CHECK dout0_1 Vdout0_1ck187 = 1.1 time = 940
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=940.025n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 940
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=940.025n

* CHECK dout0_3 Vdout0_3ck187 = 1.1 time = 940
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=940.025n

* CHECK dout0_4 Vdout0_4ck187 = 1.1 time = 940
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=940.025n

* CHECK dout0_5 Vdout0_5ck187 = 1.1 time = 940
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=940.025n

* CHECK dout0_6 Vdout0_6ck187 = 1.1 time = 940
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=940.025n

* CHECK dout0_7 Vdout0_7ck187 = 0 time = 940
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=940.025n

* CHECK dout0_8 Vdout0_8ck187 = 1.1 time = 940
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=940.025n

* CHECK dout0_9 Vdout0_9ck187 = 1.1 time = 940
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=940.025n

* CHECK dout0_10 Vdout0_10ck187 = 0 time = 940
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=940.025n

* CHECK dout0_11 Vdout0_11ck187 = 0 time = 940
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=940.025n

* CHECK dout0_12 Vdout0_12ck187 = 1.1 time = 940
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=940.025n

* CHECK dout0_13 Vdout0_13ck187 = 0 time = 940
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=940.025n

* CHECK dout0_14 Vdout0_14ck187 = 0 time = 940
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=940.025n

* CHECK dout0_15 Vdout0_15ck187 = 0 time = 940
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=940.025n

* CHECK dout0_16 Vdout0_16ck187 = 0 time = 940
.meas tran vdout0_16ck187 FIND v(dout0_16) AT=940.025n

* CHECK dout0_17 Vdout0_17ck187 = 0 time = 940
.meas tran vdout0_17ck187 FIND v(dout0_17) AT=940.025n

* CHECK dout0_18 Vdout0_18ck187 = 0 time = 940
.meas tran vdout0_18ck187 FIND v(dout0_18) AT=940.025n

* CHECK dout0_19 Vdout0_19ck187 = 0 time = 940
.meas tran vdout0_19ck187 FIND v(dout0_19) AT=940.025n

* CHECK dout0_20 Vdout0_20ck187 = 1.1 time = 940
.meas tran vdout0_20ck187 FIND v(dout0_20) AT=940.025n

* CHECK dout0_21 Vdout0_21ck187 = 0 time = 940
.meas tran vdout0_21ck187 FIND v(dout0_21) AT=940.025n

* CHECK dout0_22 Vdout0_22ck187 = 1.1 time = 940
.meas tran vdout0_22ck187 FIND v(dout0_22) AT=940.025n

* CHECK dout0_23 Vdout0_23ck187 = 0 time = 940
.meas tran vdout0_23ck187 FIND v(dout0_23) AT=940.025n

* CHECK dout0_24 Vdout0_24ck187 = 1.1 time = 940
.meas tran vdout0_24ck187 FIND v(dout0_24) AT=940.025n

* CHECK dout0_25 Vdout0_25ck187 = 0 time = 940
.meas tran vdout0_25ck187 FIND v(dout0_25) AT=940.025n

* CHECK dout0_26 Vdout0_26ck187 = 0 time = 940
.meas tran vdout0_26ck187 FIND v(dout0_26) AT=940.025n

* CHECK dout0_27 Vdout0_27ck187 = 1.1 time = 940
.meas tran vdout0_27ck187 FIND v(dout0_27) AT=940.025n

* CHECK dout0_28 Vdout0_28ck187 = 1.1 time = 940
.meas tran vdout0_28ck187 FIND v(dout0_28) AT=940.025n

* CHECK dout0_29 Vdout0_29ck187 = 1.1 time = 940
.meas tran vdout0_29ck187 FIND v(dout0_29) AT=940.025n

* CHECK dout0_30 Vdout0_30ck187 = 0 time = 940
.meas tran vdout0_30ck187 FIND v(dout0_30) AT=940.025n

* CHECK dout0_31 Vdout0_31ck187 = 1.1 time = 940
.meas tran vdout0_31ck187 FIND v(dout0_31) AT=940.025n

* CHECK dout0_0 Vdout0_0ck188 = 1.1 time = 945
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=945.025n

* CHECK dout0_1 Vdout0_1ck188 = 1.1 time = 945
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=945.025n

* CHECK dout0_2 Vdout0_2ck188 = 1.1 time = 945
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=945.025n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 945
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=945.025n

* CHECK dout0_4 Vdout0_4ck188 = 1.1 time = 945
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=945.025n

* CHECK dout0_5 Vdout0_5ck188 = 1.1 time = 945
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=945.025n

* CHECK dout0_6 Vdout0_6ck188 = 0 time = 945
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=945.025n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 945
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=945.025n

* CHECK dout0_8 Vdout0_8ck188 = 1.1 time = 945
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=945.025n

* CHECK dout0_9 Vdout0_9ck188 = 1.1 time = 945
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=945.025n

* CHECK dout0_10 Vdout0_10ck188 = 0 time = 945
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=945.025n

* CHECK dout0_11 Vdout0_11ck188 = 0 time = 945
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=945.025n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 945
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=945.025n

* CHECK dout0_13 Vdout0_13ck188 = 1.1 time = 945
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=945.025n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 945
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=945.025n

* CHECK dout0_15 Vdout0_15ck188 = 1.1 time = 945
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=945.025n

* CHECK dout0_16 Vdout0_16ck188 = 0 time = 945
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=945.025n

* CHECK dout0_17 Vdout0_17ck188 = 1.1 time = 945
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=945.025n

* CHECK dout0_18 Vdout0_18ck188 = 0 time = 945
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=945.025n

* CHECK dout0_19 Vdout0_19ck188 = 0 time = 945
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=945.025n

* CHECK dout0_20 Vdout0_20ck188 = 0 time = 945
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=945.025n

* CHECK dout0_21 Vdout0_21ck188 = 0 time = 945
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=945.025n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 945
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=945.025n

* CHECK dout0_23 Vdout0_23ck188 = 0 time = 945
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=945.025n

* CHECK dout0_24 Vdout0_24ck188 = 1.1 time = 945
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=945.025n

* CHECK dout0_25 Vdout0_25ck188 = 0 time = 945
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=945.025n

* CHECK dout0_26 Vdout0_26ck188 = 1.1 time = 945
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=945.025n

* CHECK dout0_27 Vdout0_27ck188 = 1.1 time = 945
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=945.025n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 945
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=945.025n

* CHECK dout0_29 Vdout0_29ck188 = 1.1 time = 945
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=945.025n

* CHECK dout0_30 Vdout0_30ck188 = 0 time = 945
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=945.025n

* CHECK dout0_31 Vdout0_31ck188 = 1.1 time = 945
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=945.025n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 1.1 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 1.1 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 1.1 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 1.1 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 1.1 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 1.1 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 0 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 1.1 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 1.1 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 0 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 1.1 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 1.1 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 1.1 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 1.1 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 1.1 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 1.1 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 0 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 1.1 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 0 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_0 Vdout0_0ck198 = 0 time = 995
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=995.025n

* CHECK dout0_1 Vdout0_1ck198 = 0 time = 995
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=995.025n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 995
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=995.025n

* CHECK dout0_3 Vdout0_3ck198 = 1.1 time = 995
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=995.025n

* CHECK dout0_4 Vdout0_4ck198 = 1.1 time = 995
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=995.025n

* CHECK dout0_5 Vdout0_5ck198 = 1.1 time = 995
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=995.025n

* CHECK dout0_6 Vdout0_6ck198 = 0 time = 995
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=995.025n

* CHECK dout0_7 Vdout0_7ck198 = 0 time = 995
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=995.025n

* CHECK dout0_8 Vdout0_8ck198 = 1.1 time = 995
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=995.025n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 995
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=995.025n

* CHECK dout0_10 Vdout0_10ck198 = 1.1 time = 995
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=995.025n

* CHECK dout0_11 Vdout0_11ck198 = 0 time = 995
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=995.025n

* CHECK dout0_12 Vdout0_12ck198 = 1.1 time = 995
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=995.025n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 995
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=995.025n

* CHECK dout0_14 Vdout0_14ck198 = 0 time = 995
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=995.025n

* CHECK dout0_15 Vdout0_15ck198 = 0 time = 995
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=995.025n

* CHECK dout0_16 Vdout0_16ck198 = 0 time = 995
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=995.025n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 995
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=995.025n

* CHECK dout0_18 Vdout0_18ck198 = 1.1 time = 995
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=995.025n

* CHECK dout0_19 Vdout0_19ck198 = 0 time = 995
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=995.025n

* CHECK dout0_20 Vdout0_20ck198 = 1.1 time = 995
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=995.025n

* CHECK dout0_21 Vdout0_21ck198 = 0 time = 995
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=995.025n

* CHECK dout0_22 Vdout0_22ck198 = 0 time = 995
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=995.025n

* CHECK dout0_23 Vdout0_23ck198 = 1.1 time = 995
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=995.025n

* CHECK dout0_24 Vdout0_24ck198 = 1.1 time = 995
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=995.025n

* CHECK dout0_25 Vdout0_25ck198 = 1.1 time = 995
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=995.025n

* CHECK dout0_26 Vdout0_26ck198 = 1.1 time = 995
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=995.025n

* CHECK dout0_27 Vdout0_27ck198 = 1.1 time = 995
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=995.025n

* CHECK dout0_28 Vdout0_28ck198 = 1.1 time = 995
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=995.025n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 995
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=995.025n

* CHECK dout0_30 Vdout0_30ck198 = 1.1 time = 995
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=995.025n

* CHECK dout0_31 Vdout0_31ck198 = 0 time = 995
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=995.025n

* CHECK dout0_0 Vdout0_0ck201 = 0 time = 1010
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=1010.025n

* CHECK dout0_1 Vdout0_1ck201 = 0 time = 1010
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=1010.025n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 1010
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=1010.025n

* CHECK dout0_3 Vdout0_3ck201 = 1.1 time = 1010
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=1010.025n

* CHECK dout0_4 Vdout0_4ck201 = 1.1 time = 1010
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=1010.025n

* CHECK dout0_5 Vdout0_5ck201 = 1.1 time = 1010
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=1010.025n

* CHECK dout0_6 Vdout0_6ck201 = 0 time = 1010
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=1010.025n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 1010
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=1010.025n

* CHECK dout0_8 Vdout0_8ck201 = 1.1 time = 1010
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=1010.025n

* CHECK dout0_9 Vdout0_9ck201 = 0 time = 1010
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=1010.025n

* CHECK dout0_10 Vdout0_10ck201 = 1.1 time = 1010
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=1010.025n

* CHECK dout0_11 Vdout0_11ck201 = 0 time = 1010
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=1010.025n

* CHECK dout0_12 Vdout0_12ck201 = 1.1 time = 1010
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=1010.025n

* CHECK dout0_13 Vdout0_13ck201 = 0 time = 1010
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=1010.025n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 1010
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=1010.025n

* CHECK dout0_15 Vdout0_15ck201 = 0 time = 1010
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=1010.025n

* CHECK dout0_16 Vdout0_16ck201 = 0 time = 1010
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=1010.025n

* CHECK dout0_17 Vdout0_17ck201 = 0 time = 1010
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=1010.025n

* CHECK dout0_18 Vdout0_18ck201 = 1.1 time = 1010
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=1010.025n

* CHECK dout0_19 Vdout0_19ck201 = 0 time = 1010
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=1010.025n

* CHECK dout0_20 Vdout0_20ck201 = 1.1 time = 1010
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=1010.025n

* CHECK dout0_21 Vdout0_21ck201 = 0 time = 1010
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=1010.025n

* CHECK dout0_22 Vdout0_22ck201 = 0 time = 1010
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=1010.025n

* CHECK dout0_23 Vdout0_23ck201 = 1.1 time = 1010
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=1010.025n

* CHECK dout0_24 Vdout0_24ck201 = 1.1 time = 1010
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=1010.025n

* CHECK dout0_25 Vdout0_25ck201 = 1.1 time = 1010
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=1010.025n

* CHECK dout0_26 Vdout0_26ck201 = 1.1 time = 1010
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=1010.025n

* CHECK dout0_27 Vdout0_27ck201 = 1.1 time = 1010
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=1010.025n

* CHECK dout0_28 Vdout0_28ck201 = 1.1 time = 1010
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=1010.025n

* CHECK dout0_29 Vdout0_29ck201 = 0 time = 1010
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=1010.025n

* CHECK dout0_30 Vdout0_30ck201 = 1.1 time = 1010
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=1010.025n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 1010
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=1010.025n

* CHECK dout0_0 Vdout0_0ck202 = 0 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 1.1 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 1.1 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 1.1 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 1.1 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 1.1 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 1.1 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 0 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 1.1 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 1.1 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 0 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 1.1 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 1.1 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 1.1 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 1.1 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 1.1 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 1.1 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 0 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 1.1 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 0 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck204 = 0 time = 1025
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=1025.025n

* CHECK dout0_1 Vdout0_1ck204 = 1.1 time = 1025
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=1025.025n

* CHECK dout0_2 Vdout0_2ck204 = 0 time = 1025
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=1025.025n

* CHECK dout0_3 Vdout0_3ck204 = 0 time = 1025
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=1025.025n

* CHECK dout0_4 Vdout0_4ck204 = 1.1 time = 1025
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=1025.025n

* CHECK dout0_5 Vdout0_5ck204 = 1.1 time = 1025
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=1025.025n

* CHECK dout0_6 Vdout0_6ck204 = 1.1 time = 1025
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=1025.025n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 1025
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=1025.025n

* CHECK dout0_8 Vdout0_8ck204 = 1.1 time = 1025
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=1025.025n

* CHECK dout0_9 Vdout0_9ck204 = 0 time = 1025
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=1025.025n

* CHECK dout0_10 Vdout0_10ck204 = 0 time = 1025
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=1025.025n

* CHECK dout0_11 Vdout0_11ck204 = 1.1 time = 1025
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=1025.025n

* CHECK dout0_12 Vdout0_12ck204 = 0 time = 1025
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=1025.025n

* CHECK dout0_13 Vdout0_13ck204 = 1.1 time = 1025
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=1025.025n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 1025
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=1025.025n

* CHECK dout0_15 Vdout0_15ck204 = 1.1 time = 1025
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=1025.025n

* CHECK dout0_16 Vdout0_16ck204 = 0 time = 1025
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=1025.025n

* CHECK dout0_17 Vdout0_17ck204 = 1.1 time = 1025
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=1025.025n

* CHECK dout0_18 Vdout0_18ck204 = 1.1 time = 1025
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=1025.025n

* CHECK dout0_19 Vdout0_19ck204 = 1.1 time = 1025
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=1025.025n

* CHECK dout0_20 Vdout0_20ck204 = 0 time = 1025
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=1025.025n

* CHECK dout0_21 Vdout0_21ck204 = 0 time = 1025
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=1025.025n

* CHECK dout0_22 Vdout0_22ck204 = 0 time = 1025
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=1025.025n

* CHECK dout0_23 Vdout0_23ck204 = 1.1 time = 1025
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=1025.025n

* CHECK dout0_24 Vdout0_24ck204 = 0 time = 1025
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=1025.025n

* CHECK dout0_25 Vdout0_25ck204 = 0 time = 1025
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=1025.025n

* CHECK dout0_26 Vdout0_26ck204 = 0 time = 1025
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=1025.025n

* CHECK dout0_27 Vdout0_27ck204 = 1.1 time = 1025
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=1025.025n

* CHECK dout0_28 Vdout0_28ck204 = 0 time = 1025
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=1025.025n

* CHECK dout0_29 Vdout0_29ck204 = 0 time = 1025
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=1025.025n

* CHECK dout0_30 Vdout0_30ck204 = 0 time = 1025
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=1025.025n

* CHECK dout0_31 Vdout0_31ck204 = 1.1 time = 1025
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
